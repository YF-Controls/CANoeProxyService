/* !Encoding: 65001  */
includes
{
  #include "__DiagLibrary.cin"
  #include "__cDiagService.cin"
  #include "__VariablesLib.cin"
  #include "__CaplGeneratorLib.cin"
  #include "__CANoeReportFuntionsLib.cin"
}

variables
{
  // Global variables defined within this CAPL file
}

void Ttcc5jmo2_RC_10_Ignition_Status(int64 Specify_Ign_State)
{
  TestCommandBegin(__eSet, __cSet, "Function for Ignition State Change", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`ModelGlobal::`ISw_Stat = Specify_Ign_State;
      snprintf(__cArray, 8192, "%s", "ISw_Stat");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "Specify_Ign_State");
      
      __ReportTableRow(0, __cArray2, __cAOp, Specify_Ign_State, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_11_Vehicle_state(int64 Specify_Vehicle_Living_State)
{
  TestCommandBegin(__eSet, __cSet, "Specify parameter based on the signal Inputs", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_VehSL_Master_Stat1_ST3::`VehSL_LivingStat_ST3.phys = Specify_Vehicle_Living_State;
      snprintf(__cArray, 8192, "%s", "VehSL_LivingStat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "Specify_Vehicle_Living_State");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_VehSL_Master_Stat1_ST3::`VehSL_LivingStat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, Specify_Vehicle_Living_State, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_12_Key_State(int64 Specify_Key_State)
{
  TestCommandBegin(__eSet, __cSet, "Specify Key State based on above defined Parameters", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3.phys = Specify_Key_State;
      snprintf(__cArray, 8192, "%s", "KG_Key_Rs_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "Specify_Key_State");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, Specify_Key_State, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_4_6_Key_Less_Go()
{
  TestCommandBegin(__eSet, __cSet, "Select Key Less Go", "0");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3.phys = 3;
      snprintf(__cArray, 8192, "%s", "KG_Key_Rs_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_CKG_KEY_RS_SNA");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 3, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Select Powertrain NOT READY", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::`PT4_PTCoor_PT_Rdy_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PT4_PTCoor_PT_Rdy_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_PT_RDY_V2_PT_NOT_RDY");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::`PT4_PTCoor_PT_Rdy_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_1_0_Power_Windows_Close()
{
int64 __ifExec0;
int64 __ifExec1;
int64 __ifExec2;
int64 __ifExec3;

  
  TestControlStructBegin(__cIf, "Check if Windows are not already Closed", "1");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec0 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FL_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec0 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Close button ", "2");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "3");
      {
        __Wait("1", (4 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button", "4");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "5");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Closed", "6");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if the Window Position is 0 mm", "7");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "8");
  {
    if (__DoElse(__ifExec0))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "9");
      {
        testStep(2, __cEmpty, "FL Window is already Closed");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  
  TestControlStructBegin(__cIf, "Check if Windows are not already Closed", "11");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec1 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FR_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec1 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Close button ", "12");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "13");
      {
        __Wait("1", (4 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button", "14");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "15");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Closed", "16");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if the window Position is 0 mm", "17");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "18");
  {
    if (__DoElse(__ifExec1))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "19");
      {
        testStep(2, __cEmpty, "FR Window is already Closed");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  
  TestControlStructBegin(__cIf, "Check if Windows are not already Closed", "22");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec2 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RL_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec2 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Close button ", "23");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "24");
      {
        __Wait("1", (4 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button", "25");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "26");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Closed", "27");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if the Window Position is 0 mm", "28");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "29");
  {
    if (__DoElse(__ifExec2))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "30");
      {
        testStep(2, __cEmpty, "RL Window is already Closed");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  
  TestControlStructBegin(__cIf, "Check if Windows are not already Closed", "34");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec3 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RR_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec3 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Close button ", "35");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "36");
      {
        __Wait("1", (4 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button", "37");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "38");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Closed", "39");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if the Window Position is 0 mm", "40");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "41");
  {
    if (__DoElse(__ifExec3))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "42");
      {
        testStep(2, __cEmpty, "RR Window is already Closed");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_RC_1_1_Power_Windows_Open()
{
int64 __ifExec4;
int64 __ifExec5;
int64 __ifExec6;
int64 __ifExec7;

  
  TestControlStructBegin(__cIf, "Check if Windows are not already Opened", "1");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec4 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FL_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec4 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Open button ", "2");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "3");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open  Button", "4");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "5");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Opened", "6");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "7");
  {
    if (__DoElse(__ifExec4))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "8");
      {
        testStep(2, __cEmpty, "FL Window is already Opened");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  
  TestControlStructBegin(__cIf, "Check if Windows are not already Opened", "10");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec5 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FR_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec5 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Open button ", "11");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "12");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button", "13");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "14");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Opened", "15");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "16");
  {
    if (__DoElse(__ifExec5))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "17");
      {
        testStep(2, __cEmpty, "FR Window is already Opened");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  
  TestControlStructBegin(__cIf, "Check if Windows are not already Opened", "20");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec6 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RL_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec6 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Open button ", "21");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "22");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button", "23");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "24");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window opened", "25");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "26");
  {
    if (__DoElse(__ifExec6))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "27");
      {
        testStep(2, __cEmpty, "RL Window is already Opened");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  
  TestControlStructBegin(__cIf, "Check if Windows are not already Opened", "31");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec7 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RR_Posn_Stat_ST3", "!=", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
        __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec7 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Auto Open button ", "32");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "33");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open  Button", "34");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "", "35");
      {
        __Wait("1", (0.2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for Window Opened", "36");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "37");
  {
    if (__DoElse(__ifExec7))
    {
      TestCommandBegin(__eReport, __cReport, __cEmpty, "38");
      {
        testStep(2, __cEmpty, "RR Window is alreadyOpened");
      
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_RC_1_2_Short_Stroke_High()
{
}

void Ttcc5jmo2_RC_1_3_Short_Stroke_Low()
{
}

void Ttcc5jmo2_RC_4_3_FL_Thermal_Protection()
{
  {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for FL (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for FL (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "0");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

      TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for FL (LIN)", "1");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "2");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button for FL (LIN)", "3");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "4");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Press Auto Close Button for FL (LIN)", "5");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "6");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button for FL (LIN)", "7");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "8");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestControlStructEnd(__eUndefined);
    }
    TestControlStructEnd(__eUndefined);
  }
  

  TestCommandBegin(__eCheck, __cCheck, "Check that Thermal Protection Active for FL", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_4_3_FR_Thermal_Protection()
{
  {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for FR (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for FR (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "0");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

      TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for FR (LIN)", "1");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "2");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button for FR (LIN)", "3");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "4");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Press Auto Close Button for FR (LIN)", "5");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "6");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button for FR (LIN)", "7");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "8");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestControlStructEnd(__eUndefined);
    }
    TestControlStructEnd(__eUndefined);
  }
  

  TestCommandBegin(__eCheck, __cCheck, "Check that Thermal Protection Active for FR", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_4_3_RL_Thermal_Protection()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for RL (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for RL (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "1");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

      TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for RL (LIN)", "2");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "3");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button for RL (LIN)", "4");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "5");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Press Auto Close Button for RL (LIN)", "6");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "7");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button for RL (LIN)", "8");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "9");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestControlStructEnd(__eUndefined);
    }
    TestControlStructEnd(__eUndefined);
  }
  

  TestCommandBegin(__eCheck, __cCheck, "Check that Thermal Protection Active for RL", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_RC_4_3_RR_Thermal_Protection()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for RR (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for RR (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "1");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

      TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for RR (LIN)", "2");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 5;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "3");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Open Button for RR (LIN)", "4");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "5");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Press Auto Close Button for RR (LIN)", "6");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 6;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "AUTOCLS");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 6, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 0.5 s", "7");
      {
        __Wait("1", (0.5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Release Auto Close Button for RR (LIN)", "8");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 5 s", "9");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestControlStructEnd(__eUndefined);
    }
    TestControlStructEnd(__eUndefined);
  }
  

  TestCommandBegin(__eCheck, __cCheck, "Check that Thermal Protection Active for RR", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_RC_4_7_UI_Handler_Key_Inside()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  TestCommandBegin(__eSet, __cSet, "Power window UI property request - TRUE", "17");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::`PW_UI_FL_Prop_Rq_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_UI_FL_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::`PW_UI_FL_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::`PW_UI_FR_Prop_Rq_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_UI_FR_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::`PW_UI_FR_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::`PW_UI_RL_Prop_Rq_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_UI_RL_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::`PW_UI_RL_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::`PW_UI_RR_Prop_Rq_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_UI_RR_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::`PW_UI_RR_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_4_8_UI_Handler_No_Key()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "7");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "11");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Enable UI Handler Request through Variant Coding", "15");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_Enable_UI_Fensterheber_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  TestCommandBegin(__eSet, __cSet, "Power window UI property request - FALSE", "18");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::`PW_UI_FL_Prop_Rq_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_UI_FL_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::`PW_UI_FL_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::`PW_UI_FR_Prop_Rq_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_UI_FR_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::`PW_UI_FR_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::`PW_UI_RL_Prop_Rq_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_UI_RL_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::`PW_UI_RL_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::`PW_UI_RR_Prop_Rq_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_UI_RR_Prop_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::`PW_UI_RR_Prop_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_13_1_Child_Security_Lock_Active()
{
int64 __ifExec8;

  
  TestControlStructBegin(__cIf, "Check Whether CSL is False or Inactive", "0");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec8 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "CSL_LHD_Inact_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 1, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "CSL_LHD_Inact_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec8 = 1;

      TestCommandBegin(__eSet, __cSet, "Press CSL", "1");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35.phys = 1;
          snprintf(__cArray, 8192, "%s", "CSL_Inact_ST35");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_FLS_TRU_FALSE");
          
          __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 2 s", "2");
      {
        __Wait("1", (2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for CSL LED ON", "3");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`LIN::dbNode::`DM::`Door_Stat_LIN_ST3_DOOR::`CSL_SwLED_Rq_ST3_DOOR, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "CSL_SwLED_Rq_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`LIN::dbNode::`DM::`Door_Stat_LIN_ST3_DOOR::`CSL_SwLED_Rq_ST3_DOOR, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check for CSL Active", "4");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "CSL_LHD_Inact_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "5");
  {
    if (__DoElse(__ifExec8))
    {
    }
  }
  TestControlStructEnd(__eUndefined);

}

void Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive()
{
int64 __ifExec9;

  
  TestControlStructBegin(__cIf, "Check Whether CSL is True or Active", "0");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec9 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = __expr0;
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "CSL_LHD_Inact_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 2, "!=") == 1;
        snprintf(__cArray, 8192, "%s", "CSL_LHD_Inact_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec9 = 1;

      TestCommandBegin(__eSet, __cSet, "Press CSL", "1");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35.phys = 2;
          snprintf(__cArray, 8192, "%s", "CSL_Inact_ST35");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_FLS_TRU_TRUE");
          
          __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait 2 s", "2");
      {
        __Wait("1", (2 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eCheck, __cCheck, "Check for CSL LED OFF", "3");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`LIN::dbNode::`DM::`Door_Stat_LIN_ST3_DOOR::`CSL_SwLED_Rq_ST3_DOOR, 1, "==") == 1;
          snprintf(__cArray, 8192, "%s", "CSL_SwLED_Rq_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "FALSE");
          __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
          __ReportLValueOrSignalNotOnline(`LIN::dbNode::`DM::`Door_Stat_LIN_ST3_DOOR::`CSL_SwLED_Rq_ST3_DOOR, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check for CSL Inactive", "4");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "CSL_Inact_ST35");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_FLS_TRU_TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestControlStructBegin(__cElse, "", "5");
  {
    if (__DoElse(__ifExec9))
    {
    }
  }
  TestControlStructEnd(__eUndefined);

}

void Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "17");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "19");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "20");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


}

void Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code the Parameters", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "17");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "19");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Parameters", "20");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftAutSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManOeffnen_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableUmluftManSchliessn_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_1_SecOC_With_Role(int64 Role)
{
  TestCommandBegin(__eSet, __cSet, "", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SeckTickSynchronization::`ExecuteAuthentication = 1;
      snprintf(__cArray, 8192, "%s", "ExecuteAuthentication");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 1, __cArray3);
      
  
    }
    {
      @sysvarInt::`SeckTickSynchronization::`CheckBox_DeactivateTesterPresent = 0;
      snprintf(__cArray, 8192, "%s", "CheckBox_DeactivateTesterPresent");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    {
      @sysvarInt::`DAG_Diagnostics::`DiagnosticsRole = Role;
      snprintf(__cArray, 8192, "%s", "DiagnosticsRole");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "Role");
      
      __ReportTableRow(0, __cArray2, __cAOp, Role, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`LocalAuthentication::`TargetMode = 0;
      snprintf(__cArray, 8192, "%s", "TargetMode");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "AuthForAllTargets");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press Authenticate Button", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`LocalAuthentication::`Button_Authenticate = 1;
      snprintf(__cArray, 8192, "%s", "Button_Authenticate");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Authenticate Button", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`LocalAuthentication::`Button_Authenticate = 0;
      snprintf(__cArray, 8192, "%s", "Button_Authenticate");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Result is True", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(sysvarInt::`LocalAuthentication::`AuthResult, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "AuthResult");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportCell(@sysvarInt::`LocalAuthentication::`AuthResult);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SeckTickSynchronization::`Button_SecTickCountSync = 1;
      snprintf(__cArray, 8192, "%s", "Button_SecTickCountSync");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (500 * 1000000LL), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SeckTickSynchronization::`Button_SecTickCountSync = 0;
      snprintf(__cArray, 8192, "%s", "Button_SecTickCountSync");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "", "11");
  {
  
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 15 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
                        snprintf(__cArray, elCount(__cArray), "System variable '%s'", "LED_Sync_Result");
      __setFailed |= testJoinSignal(sysvarInt::`SeckTickSynchronization::`LED_Sync_Result, __cArray,
                        delegate dword(sysvar * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 1, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        __bVerdict = testWaitForAllJoinedEventsNS(__time) > 0;
        __ReportTableHead5Columns("Waited for occurrence of 1 value condition.", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
                        __csr = CheckSignalMatch(sysvarInt::`SeckTickSynchronization::`LED_Sync_Result, 1, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "LED_Sync_Result");
                        snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
                        snprintf(__cArray3, 8192, "%s", "");
                        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
                        __ReportCell(@sysvarInt::`SeckTickSynchronization::`LED_Sync_Result);
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "12");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

}

void Ttcc5jmo2_BS_2_Start_Values()
{
  TestCommandBegin(__eSet, __cSet, "Selecting \"FC\" Body Style", "0");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List01_BodyStyle_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "EVC_List01_BodyStyle_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List01_BodyStyle_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Selecting \"BR174\" Carline", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List02_VehLine_ST3.phys = 24;
      snprintf(__cArray, 8192, "%s", "EVC_List02_VehLine_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List02_VehLine_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 24, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Selecting \"DEU\" Country Code", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List06_Country_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "EVC_List06_Country_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List06_Country_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Selecting \"LHD\" as Steering Variant", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List03_StStyle_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_List03_StStyle_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List03_StStyle_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Set EVC Values", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_CfgList_01_08_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgList_01_08_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_CfgList_01_08_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List08_HL_Style_ST3.phys = 15;
      snprintf(__cArray, 8192, "%s", "EVC_List08_HL_Style_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_EVC_HL_STYLE_ST3_OTHER");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List08_HL_Style_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 15, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List07_TxStyle_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "EVC_List07_TxStyle_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_EVC_TXSTYLE_ST3_AUTOM_7");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgList_01_08_Pr5_ST3::`EVC_List07_TxStyle_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::`PN14_DDP_Sw_Stat_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "PN14_DDP_Sw_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_PN14_TDP_SW_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::`PN14_DDP_Sw_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Select KEY = INSIDE", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "KG_Key_Rs_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_CKG_KEY_RS_INSIDE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::`KG_Key_Rs_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Ignition ON", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::`ISw_Stat_ST3.phys = 4;
      snprintf(__cArray, 8192, "%s", "ISw_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_ISW_STAT_IGN_ON");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::`ISw_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 4, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Set EVC Values", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_01_26_Pr5_ST3::`EVC_CfgBit_01_26_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_01_26_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_01_26_Pr5_ST3::`EVC_CfgBit_01_26_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_CfgBit_27_4C_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_27_4C_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_CfgBit_27_4C_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_4D_72_Pr5_ST3::`EVC_CfgBit_4D_72_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_4D_72_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_4D_72_Pr5_ST3::`EVC_CfgBit_4D_72_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_CfgBit_73_98_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_73_98_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_CfgBit_73_98_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_99_BE_Pr5_ST3::`EVC_CfgBit_99_BE_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_99_BE_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_99_BE_Pr5_ST3::`EVC_CfgBit_99_BE_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_BF_E4_Pr5_ST3::`EVC_CfgBit_BF_E4_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_CfgBit_BF_E4_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_EVC_STAT_PROG");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_BF_E4_Pr5_ST3::`EVC_CfgBit_BF_E4_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Mirror Heating = OFF", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_ExtMirr_UI_Rq_ST3::`MirrHeat_UI_Rq_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "MirrHeat_UI_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_IDLE_ON_OFF_SNA_3H_OFF");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_ExtMirr_UI_Rq_ST3::`MirrHeat_UI_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Remote Start = FALSE", "9");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_RemStart_Stat_ST3::`RemStart_IgnCtrl_Actv_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "RemStart_IgnCtrl_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_RemStart_Stat_ST3::`RemStart_IgnCtrl_Actv_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_LHC_Request_ST3::`PN14_LHC_MirrHt_Rq_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "PN14_LHC_MirrHt_Rq_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_LHC_Request_ST3::`PN14_LHC_MirrHt_Rq_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Mirror Dimming = 0", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`OHCM::`OHCM_BODY1_Container_ST3_EC_Stat_LIN_ST3::`Mirr_Adzzl_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "Mirr_Adzzl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`OHCM::`OHCM_BODY1_Container_ST3_EC_Stat_LIN_ST3::`Mirr_Adzzl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "", "12");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_THC_HVAC_Stat1_ST3::`DewTemp_ST3.phys = 20;
      snprintf(__cArray, 8192, "%s", "DewTemp_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_THC_HVAC_Stat1_ST3::`DewTemp_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 20, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "", "13");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::`AirTemp_Outsd_Disp_ST3.phys = 25;
      snprintf(__cArray, 8192, "%s", "AirTemp_Outsd_Disp_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::`AirTemp_Outsd_Disp_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 25, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Supply Voltage is 12.5v", "14");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::`PN14_SupBat_Volt_ST3.phys = 12.5;
      snprintf(__cArray, 8192, "%s", "PN14_SupBat_Volt_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::`PN14_SupBat_Volt_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 12.5, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Set EVC Values", "15");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_42_883_Avl_ST3.phys = 0;
      snprintf(__cArray, 8192, "%s", "EVC_42_883_Avl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_42_883_Avl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_4A_500_Avl_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_4A_500_Avl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_27_4C_Pr5_ST3::`EVC_4A_500_Avl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_4D_72_Pr5_ST3::`EVC_54_275_Avl_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_54_275_Avl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_4D_72_Pr5_ST3::`EVC_54_275_Avl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_8A_234_Avl_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_8A_234_Avl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_8A_234_Avl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_89_233_Avl_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "EVC_89_233_Avl_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_EVC_CfgBit_73_98_Pr5_ST3::`EVC_89_233_Avl_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Set Door Latch as Closed", "16");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_3_1_Enable_VSL_Living()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMFL", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMFR", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMRL", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMRR", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "TRUE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "17");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "19");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "20");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("TRUE", 8192);
        snprintf(__cArray2, 8192, "%s", "TRUE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_3_2_Disable_VSL_Living()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMFL", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMFR", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMRL", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Activate FuVo Living for DMRR", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", "FALSE");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "17");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "19");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Values", "20");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Function_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "WL_Function_VariantCoding/PPWC_enableFuVoLiving_b", __bDiagValueArray, __cDiagValueArray);
        CheckCaplGenVarStringBufferConsistency(__cDiagValueArray, 8192);
        snprintf(__cArray, 8192, "%s", __cDiagValueArray);
        CheckLiteralGetStringBufferConsistency("FALSE", 8192);
        snprintf(__cArray2, 8192, "%s", "FALSE");
        __csr = strncmp(__cArray, __cArray2, 8192) == 0;
        snprintf(__cArray3, 8192, "%s", "Diagnostic parameter \'WL_Function_VariantCoding/PPWC_enableFuVoLiving_b\'");
        snprintf(__cArray4, 8192, "%s", __cArray3);
        snprintf(__cArray5, 8192, "%s", "");
        __ReportTableRow(0, __cArray4, "==", __cArray2, __cArray5);
        __ReportCell(__cArray);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "enter Extended Session", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.Extended_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "STDS_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'STDS_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'STDS_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Denormalization through Routine for Window FL", "1");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.PWC_WindowLift_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WinLift_Rq", "DENORM");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WinLift_Rq'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RC_STR_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RC_STR_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RC_STR_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (5 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "", "3");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_FL_Norm_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 1, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAllJoinedEventsNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 1, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_FL_Norm_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
                        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "enter Extended Session", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.Extended_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "STDS_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'STDS_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'STDS_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Denormalization through Routine for Window FR", "5");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.PWC_WindowLift_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WinLift_Rq", "DENORM");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WinLift_Rq'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RC_STR_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RC_STR_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RC_STR_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (5 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "", "7");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_FR_Norm_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 1, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAllJoinedEventsNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 1, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_FR_Norm_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
                        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "enter Extended Session", "8");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.Extended_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "STDS_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'STDS_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'STDS_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Denormalization through Routine for Window RL", "9");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.PWC_WindowLift_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WinLift_Rq", "DENORM");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WinLift_Rq'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RC_STR_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RC_STR_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RC_STR_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (5 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "", "11");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_RL_Norm_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 1, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAllJoinedEventsNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 1, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_RL_Norm_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
                        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "enter Extended Session", "12");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.Extended_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "STDS_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'STDS_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'STDS_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Denormalization through Routine for Window RR", "13");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.PWC_WindowLift_Start __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WinLift_Rq", "DENORM");
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WinLift_Rq'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RC_STR_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RC_STR_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RC_STR_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "", "14");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_RR_Norm_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 1, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAllJoinedEventsNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 1, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_RR_Norm_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
                        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check whether Windows are Denormed", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_4_2_Normalization_Of_Windows()
{
int64 __ifExec10;
int64 __ifExec11;
int64 __ifExec12;
int64 __ifExec13;

  TestCommandBegin(__eFaultMemoryClear, __cFaultMemoryClear, "", "1");
  {
    long __res;
    long __dtc;
    
    DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_always);
    TestStep("Query fault memory", "Clearing fault memory of target Diagnostic ECU 'DMFL_MMA'");
  
    __res = TestWaitForDiagTroubleCodesCleared("DMFL_MMA", -1, cDiagAppTimeoutDefault);
    if (__EvaluateWaitResWithVerdict("DMFL_MMA", __res, 1, "DTC cleared successfully"))
      TestReportWriteFaultMemoryDetails("DMFL_MMA", __bVerdict); }
  TestCommandEnd();


  TestCommandBegin(__eFaultMemoryDtc, __cFaultMemoryDtc, "", "2");
  {
    long  __res;
    dword __statusByte;
   
    DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
    TestStep("Query fault memory", "Reading DTCs from diagnostic ECU 'DMFL_MMA'");
  
    __statusByte = -1;
  
    __res = TestWaitForDiagTroubleCodes("DMFL_MMA", __statusByte, cDiagAppTimeoutDefault);
    if(__EvaluateWaitResWithVerdict("DMFL_MMA", __res, 1))
    {
      __bVerdict = __eVerdictPass;
      TestReportWriteFaultMemoryDetails("DMFL_MMA", __bVerdict);  
    }
  }
  TestCommandEnd();


  
  TestControlStructBegin(__cIf, "Check Whether the Windows are Denormalized", "3");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec10 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 1, "==") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s(", __cArray);
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FL_Norm_ST3", "==", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s)", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 1, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FL_Norm_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec10 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Manual Open button", "4");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "MANOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait for 5 sec", "5");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Relase Manual Open button", "6");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s(", __cArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FL_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s)", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s(", __cArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FL_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s)", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "7");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_1_Manual_Close_FL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "6033ca22-15dd-4f4c-ba50-0ca38c85a9e2");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "9");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_1_Manual_Close_FL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "6033ca22-15dd-4f4c-ba50-0ca38c85a9e2");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "11");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_1_Manual_Close_FL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "6033ca22-15dd-4f4c-ba50-0ca38c85a9e2");
          }


          TestControlStructEnd(__eUndefined);
        }
        TestControlStructEnd(__eUndefined);
      }
      

      TestCommandBegin(__eCheck, __cCheck, "Check Whether Normalization is TRUE", "13");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Norm_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Norm_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if Window is Closed", "14");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "window Position is 0 mm", "15");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestCommandBegin(__eFaultMemoryClear, __cFaultMemoryClear, "", "17");
  {
    long __res;
    long __dtc;
    
    DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_always);
    TestStep("Query fault memory", "Clearing fault memory of target Diagnostic ECU 'DMFR_MMA'");
  
    __res = TestWaitForDiagTroubleCodesCleared("DMFR_MMA", -1, cDiagAppTimeoutDefault);
    if (__EvaluateWaitResWithVerdict("DMFR_MMA", __res, 1, "DTC cleared successfully"))
      TestReportWriteFaultMemoryDetails("DMFR_MMA", __bVerdict); }
  TestCommandEnd();


  TestCommandBegin(__eFaultMemoryDtc, __cFaultMemoryDtc, "", "18");
  {
    long  __res;
    dword __statusByte;
   
    DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
    TestStep("Query fault memory", "Reading DTCs from diagnostic ECU 'DMFR_MMA'");
  
    __statusByte = -1;
  
    __res = TestWaitForDiagTroubleCodes("DMFR_MMA", __statusByte, cDiagAppTimeoutDefault);
    if(__EvaluateWaitResWithVerdict("DMFR_MMA", __res, 1))
    {
      __bVerdict = __eVerdictPass;
      TestReportWriteFaultMemoryDetails("DMFR_MMA", __bVerdict);  
    }
  }
  TestCommandEnd();


  
  TestControlStructBegin(__cIf, "Check Whether the Windows are Denormalized", "19");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec11 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 1, "==") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s(", __cArray);
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FR_Norm_ST3", "==", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s)", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 1, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FR_Norm_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec11 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Manual Open button", "20");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "MANOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait for 5 sec", "21");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Relase Manual Open button", "22");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s(", __cArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FR_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s)", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s(", __cArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_FR_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s)", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "23");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_2_Manual_Close_FR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "14a6e4f4-3b2e-406a-b3a2-74aabdcd3ce6");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "25");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_2_Manual_Close_FR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "14a6e4f4-3b2e-406a-b3a2-74aabdcd3ce6");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "27");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_2_Manual_Close_FR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "14a6e4f4-3b2e-406a-b3a2-74aabdcd3ce6");
          }


          TestControlStructEnd(__eUndefined);
        }
        TestControlStructEnd(__eUndefined);
      }
      

      TestCommandBegin(__eCheck, __cCheck, "Check Whether Normalization is TRUE", "29");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Norm_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Norm_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if Window is Closed", "30");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Window is 0 mm", "31");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestCommandBegin(__eFaultMemoryClear, __cFaultMemoryClear, "", "33");
  {
    long __res;
    long __dtc;
    
    DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_always);
    TestStep("Query fault memory", "Clearing fault memory of target Diagnostic ECU 'DMRL_MMA'");
  
    __res = TestWaitForDiagTroubleCodesCleared("DMRL_MMA", -1, cDiagAppTimeoutDefault);
    if (__EvaluateWaitResWithVerdict("DMRL_MMA", __res, 1, "DTC cleared successfully"))
      TestReportWriteFaultMemoryDetails("DMRL_MMA", __bVerdict); }
  TestCommandEnd();


  TestCommandBegin(__eFaultMemoryDtc, __cFaultMemoryDtc, "", "34");
  {
    long  __res;
    dword __statusByte;
   
    DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
    TestStep("Query fault memory", "Reading DTCs from diagnostic ECU 'DMRL_MMA'");
  
    __statusByte = -1;
  
    __res = TestWaitForDiagTroubleCodes("DMRL_MMA", __statusByte, cDiagAppTimeoutDefault);
    if(__EvaluateWaitResWithVerdict("DMRL_MMA", __res, 1))
    {
      __bVerdict = __eVerdictPass;
      TestReportWriteFaultMemoryDetails("DMRL_MMA", __bVerdict);  
    }
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  
  TestControlStructBegin(__cIf, "Check Whether the Windows are Denormalized", "36");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec12 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 1, "==") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s(", __cArray);
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RL_Norm_ST3", "==", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s)", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 1, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RL_Norm_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec12 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Manual Open button", "37");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "MANOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait for 5 sec", "38");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Relase Manual Open button", "39");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s(", __cArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RL_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s)", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s(", __cArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RL_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s)", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "40");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_3_Manual_Close_RL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "4b91ac28-fb09-4d7b-bae2-677b177607e4");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "42");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_3_Manual_Close_RL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "4b91ac28-fb09-4d7b-bae2-677b177607e4");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "44");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_3_Manual_Close_RL", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "4b91ac28-fb09-4d7b-bae2-677b177607e4");
          }


          TestControlStructEnd(__eUndefined);
        }
        TestControlStructEnd(__eUndefined);
      }
      

      TestCommandBegin(__eCheck, __cCheck, "Check Whether Normalization is TRUE", "46");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Norm_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Norm_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "check if Window is Closed", "47");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Window Posiion is 0 mm", "48");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  TestCommandBegin(__eFaultMemoryClear, __cFaultMemoryClear, "", "50");
  {
    long __res;
    long __dtc;
    
    DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_always);
    TestStep("Query fault memory", "Clearing fault memory of target Diagnostic ECU 'DMRR_MMA'");
  
    __res = TestWaitForDiagTroubleCodesCleared("DMRR_MMA", -1, cDiagAppTimeoutDefault);
    if (__EvaluateWaitResWithVerdict("DMRR_MMA", __res, 1, "DTC cleared successfully"))
      TestReportWriteFaultMemoryDetails("DMRR_MMA", __bVerdict); }
  TestCommandEnd();


  TestCommandBegin(__eFaultMemoryDtc, __cFaultMemoryDtc, "", "51");
  {
    long  __res;
    dword __statusByte;
   
    DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
    TestStep("Query fault memory", "Reading DTCs from diagnostic ECU 'DMRR_MMA'");
  
    __statusByte = -1;
  
    __res = TestWaitForDiagTroubleCodes("DMRR_MMA", __statusByte, cDiagAppTimeoutDefault);
    if(__EvaluateWaitResWithVerdict("DMRR_MMA", __res, 1))
    {
      __bVerdict = __eVerdictPass;
      TestReportWriteFaultMemoryDetails("DMRR_MMA", __bVerdict);  
    }
  }
  TestCommandEnd();


  
  TestControlStructBegin(__cIf, "Check Whether the Windows are Denormalized", "52");
  {
    int64 __condition;
    {
      int64 __expr0;
      __ifExec13 = 0;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 1, "==") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
        snprintf(__cConditionArray, 8192, "%s", "");
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s(", __cArray);
        snprintf(__cCompareArray, 8192, "%s", "");
        snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RR_Norm_ST3", "==", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        snprintf(__cArray, 8192, "%s", __cCompareArray);
        snprintf(__cCompareArray, 8192, "( %s )", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s)", __cArray);
        snprintf(__cArray, 8192, "%s", __cConditionArray);
        snprintf(__cConditionArray, 8192, "%s %s", "If", __cArray);
  
      __ReportConditionTableHead(__cConditionArray, __condition);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 1, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RR_Norm_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
        __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cIfCondition);
    }
  
    if(__condition)
    {  
      __ifExec13 = 1;

      TestCommandBegin(__eSet, __cSet, "Press Manual Open button", "53");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "MANOPN");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      TestCommandBegin(__eWait, __cWait, "Wait for 5 sec", "54");
      {
        __Wait("1", (5 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestCommandBegin(__eSet, __cSet, "Relase Manual Open button", "55");
      {
        __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
        {
          $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
          snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
          snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "NPSD");
          
          __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
          __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
          
      
        }
        __ReportTableEndTestStep("1");
      }
      TestCommandEnd();


      {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s(", __cArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RR_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s)", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 2, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      __condition = (__expr0);
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s(", __cArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_RR_Norm_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s)", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check if Normalization is not TRUE (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "56");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 2, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Norm_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "!=", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_4_Manual_Close_RR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "02820149-ac0d-4188-a578-712ac6e94b78");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "58");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_4_Manual_Close_RR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "02820149-ac0d-4188-a578-712ac6e94b78");
          }


          TestCommandBegin(__eWait, __cWait, "Wait for 2 sec", "60");
          {
            __Wait("1", (2 * 1000000000LL), 1000000000, "");
          }
          TestCommandEnd();

          {
            CreateTTEIFFunction("Ttcc5jmo2_BS_5_4_Manual_Close_RR", __eFct, __eLocal);
            CallInterfaceFunction(__cEmpty, __cEmpty, "02820149-ac0d-4188-a578-712ac6e94b78");
          }


          TestControlStructEnd(__eUndefined);
        }
        TestControlStructEnd(__eUndefined);
      }
      

      TestCommandBegin(__eCheck, __cCheck, "Check Whether Normalization is TRUE", "62");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Norm_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Norm_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Check if Window is Closed", "63");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
          __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


      TestCommandBegin(__eCheck, __cCheck, "Window Position is 0 mm", "64");
      {
        __bVerdict = __eVerdictPass;
        __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
        {
          __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 2, "<=") == 1;
          snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
          snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
          snprintf(__cArray3, 8192, "%s", "");
          __ReportTableRow(0, __cArray2, "<=", 2, __cArray3);
          __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray5);
          __ReportCell(__cArray5);
          __ReportCellResult(__csr, __ePassFail);
      
          __bVerdict = __bVerdict && __csr;
        }
        __ReportTableEndVerdict("1", __bVerdict);
      }
      TestCommandEnd();


    }
  }
  TestControlStructEnd(__eUndefined);

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_BS_5_1_Manual_Close_FL()
{
  TestCommandBegin(__eSet, __cSet, "Press Manual Close Button", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 sec", "2");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "3");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_FL_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 2, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 2, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
                        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "wait for 5 sec", "4");
  {
    __Wait("1", (5 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "6");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_FL_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 0, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
                        __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

}

void Ttcc5jmo2_BS_5_2_Manual_Close_FR()
{
  TestCommandBegin(__eSet, __cSet, "Press Manual Close Button", "1");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 sec", "2");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "3");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_FR_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 2, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 2, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
                        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "wait for 4 sec", "4");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "6");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_FR_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 0, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
                        __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

}

void Ttcc5jmo2_BS_5_3_Manual_Close_RL()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press Manual Close Button", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 sec", "3");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "4");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_RL_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 2, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 2, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
                        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "wait for 4 sec", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "7");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_RL_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 0, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
                        __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_BS_5_4_Manual_Close_RR()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press Manual Close Button", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 sec", "3");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "4");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_RR_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 2, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 2, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
                        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "wait for 4 sec", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eAwaitValueMatch, __cAwaitValueMatch, "Check the response Signal", "7");
  {
  
    dword __signalTimes[1];
    int64 __time;
    long __setFailed;
    __setFailed = 0;
    __time = 1 * 1000000000LL;
    if (__time < 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __time / ((float)1000000000), "s");
    }
    else
    {
      __signalTimes[0] = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3);
                        snprintf(__cArray, elCount(__cArray), "PDU signal '%s'", "PW_Adj_RR_Dr_FL_ST3");
      __setFailed |= testJoinSignal(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray, 1,
                        delegate dword(signal * __cbParam)
                        {
                          __csr = CheckSignalMatch(__cbParam, 0, "==") == 1;
                          return __csr;
                        }) < 0;
      if (__setFailed != 0)
      {
        testStepErrorInTestSystem(0, "1", "Unable to set value condition.");
      }
      else
      {
        int64 __occurrenceTime;
        __bVerdict = testWaitForAnyJoinedEventNS(__time) > 0;
        __ReportTableHead6Columns("Waited for occurrence of any of 1 value condition and signal updates.", __cTSym, __cTOp, __cRefVal, __cActual, __cEmpty, __cRes);
                        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
                        snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
                        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
                        snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
                        __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
                        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
                        __ReportCell(__cArray5);
                        
                        {
                          dword __signalTime;
                          __signalTime = getSignalTime(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3);
                          if (__signalTime > __signalTimes[0])
                          {
                            __ReportCell(__cEmpty);
                          }
                          else
                          {
                            __ReportCell("(no update)");
                            __csr = 0;
                          }
                        }
                        __ReportCellResult(__csr, __ePassFail);
        __ReportTableEndVerdict("1", __bVerdict);
      }
    }
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


}

void Ttcc5jmo2_BS_6_1_Start_Variant_Coding(char Specify_ECU_Name[])
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_1_SecOC_With_Role", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9cf4ae6e-8846-4ca3-a90c-72b92aa3a6da");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_11_Enter_Extended_Session_All_ECUs", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "7095be39-9e8b-4b46-9ed4-65e56cbe801a");
  }


  TestCommandBegin(__eSet, __cSet, "", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      CheckTteVariableGetStringBufferConsistency(Specify_ECU_Name, "Specify_ECU_Name", 8192);
      snprintf(__cArray, 8192, "%s", Specify_ECU_Name);
      {
        sysvar * __systemVariable;
        __systemVariable = sysvarString::`LocalAuthentication::`DiagTarget;
        CheckSysVarSetBufferConsistency(sysSetVariableString(sysvarString::`LocalAuthentication::`DiagTarget, __cArray), __systemVariable.name);
      }
      snprintf(__cArray2, 8192, "%s", "LocalAuthentication::DiagTarget");
      snprintf(__cArray3, 8192, "%s '%s'", __cSysVar, __cArray2);
      snprintf(__cArray4, 8192, "%s", "Specify_ECU_Name");
      
      __ReportTableRow(0, __cArray3, __cAOp, __cArray, __cArray4);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press Start Coding button", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SecVarCodingPanel::`Button_CodingStart = 1;
      snprintf(__cArray, 8192, "%s", "Button_CodingStart");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Start Coding Button", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SecVarCodingPanel::`Button_CodingStart = 0;
      snprintf(__cArray, 8192, "%s", "Button_CodingStart");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that LED is glown", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(sysvarInt::`SecVarCodingPanel::`LED_CodingStart, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "LED_CodingStart");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportCell(@sysvarInt::`SecVarCodingPanel::`LED_CodingStart);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_6_2_Finish_Variant_Coding()
{
  TestCommandBegin(__eSet, __cSet, "Press Coding Finished Button", "0");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SecVarCodingPanel::`Button_CodingFinished = 1;
      snprintf(__cArray, 8192, "%s", "Button_CodingFinished");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Release Coding Finished Button", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`SecVarCodingPanel::`Button_CodingFinished = 0;
      snprintf(__cArray, 8192, "%s", "Button_CodingFinished");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      
      __ReportTableRow(0, __cArray2, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that LED is glown", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(sysvarInt::`SecVarCodingPanel::`LED_CodingFinished, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "LED_CodingFinished");
      snprintf(__cArray2, 8192, "%s '%s'", __cSysVar, __cArray);
      snprintf(__cArray3, 8192, "%s", "");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportCell(@sysvarInt::`SecVarCodingPanel::`LED_CodingFinished);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_7_ALL_DEACT_Thermal_Protection()
{
  {
      snprintf(__cConditionArray, 8192, "%s", "");
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s(", __cArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
    snprintf(__cCompareArray, 8192, "%s", "");
    snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
    snprintf(__cArray, 8192, "%s", __cCompareArray);
    snprintf(__cCompareArray, 8192, "( %s )", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s)", __cArray);
    snprintf(__cArray, 8192, "%s", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);

    snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for any of the Windows (", __cConditionArray);
    snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
    TestControlStructBegin(__cWhile, __cConditionArray, "0");
    while(1)
    {
      int64 __expr0, __expr1, __expr2, __expr3;
      int64 __condition;
  
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 1, "!=") == 1;
      }
      {
        __expr0 = __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 1, "!=") == 1;
      }
      {
        __expr1 = __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 1, "!=") == 1;
      }
      {
        __expr2 = __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 1, "!=") == 1;
      }
      {
        __expr3 = __csr;
      }
      __condition = (__expr0 || __expr1 || __expr2 || __expr3);
  
          snprintf(__cConditionArray, 8192, "%s", "");
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s(", __cArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cArray, __cCompareArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_FR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RL_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
      snprintf(__cCompareArray, 8192, "%s", "");
      snprintf(__cCompareArray, 8192, "%s%s%s", "PW_ThermProt_RR_Actv_ST3", "!=", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      snprintf(__cArray, 8192, "%s", __cCompareArray);
      snprintf(__cCompareArray, 8192, "( %s )", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s%s", __cArray, " or ", __cCompareArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s)", __cArray);
      snprintf(__cArray, 8192, "%s", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s %s", "While", __cArray);
  
      snprintf(__cConditionArray, 8192, "%s%s", "Check Whether Thermal Protection is Inactive for any of the Windows (", __cConditionArray);
      snprintf(__cConditionArray, 8192, "%s%s", __cConditionArray, ")");
      if(__condition == 1)
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : true");
      }
      else
      {
        snprintf(__cArray2, 8192, "%s%s", __cConditionArray, " : false");
      }
      TestControlStructBegin(__cWhileIteration, __cArray2, "0");
      {
      __ReportTableHead5Columns("Condition", __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 1, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 1, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 1, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      {
            __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 1, "!=") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "!=", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __eTrueFalse); 
      }
      __ReportTableEndCondition(__cWhileCondition, 1);
  
      if(__LoopIsBlocking())
      {
        TestControlStructEnd(__eErrorInTestSystem);
        break;
      }
  
      if (0 == __condition)
      {
        TestControlStructEnd(__eUndefined);
        break;
      }
    }

      TestCommandBegin(__eWait, __cWait, "", "1");
      {
        __Wait("1", (1 * 1000000000LL), 1000000000, "");
      }
      TestCommandEnd();

      TestControlStructEnd(__eUndefined);
    }
    TestControlStructEnd(__eUndefined);
  }
  

  TestCommandBegin(__eCheck, __cCheck, "Check for Thermal Protection Inactive", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_ThermProt_FL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_FR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_ThermProt_FR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RL_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_ThermProt_RL_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_ThermProt_RR_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_ThermProt_RR_Actv_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_8_Remote_Start(int64 Specify_Remote_Start_State)
{
  TestCommandBegin(__eSet, __cSet, "Specify Remote Start state ", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_RemStart_Stat_ST3::`RemStart_IgnCtrl_Actv_ST3.phys = Specify_Remote_Start_State;
      snprintf(__cArray, 8192, "%s", "RemStart_IgnCtrl_Actv_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "Specify_Remote_Start_State");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_RemStart_Stat_ST3::`RemStart_IgnCtrl_Actv_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, Specify_Remote_Start_State, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


}

void Ttcc5jmo2_BS_9_1_Coding_of_Temperatures()
{
  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFL_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code Temperatures", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Thermal_Protection_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", 50);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", 60);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", 70);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMFR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code Temperatures", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Thermal_Protection_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", 50);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", 60);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", 70);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code Temperatures", "9");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Thermal_Protection_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", 50);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", 60);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", 70);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_1_Start_Variant_Coding", __eFct, __eLocal);
    AddIFParameterChar("DMRR_MMA");
    CallInterfaceFunction(__cEmpty, __cEmpty, "53bd8c9d-2bd3-41d5-94b7-ec0316b8648c");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Code Temperatures", "13");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRR_MMA.* __resp;
    DiagRequest DMRR_MMA.WL_Thermal_Protection_VariantCoding_Write __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", 50);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", 60);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2'");
            break;
          }
        }
        {
          __res = __DiagSetParameter(__req, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", 70);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3'");
            break;
          }
        }
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_6_2_Finish_Variant_Coding", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cd40164d-e635-491b-872d-7720bd8b815b");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Temperatures", "16");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFL_MMA.* __resp;
    DiagRequest DMFL_MMA.WL_Thermal_Protection_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 50, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 50, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 60, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 60, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 70, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 70, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Temperatures", "17");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMFR_MMA.* __resp;
    DiagRequest DMFR_MMA.WL_Thermal_Protection_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMFR_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMFR_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 50, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 50, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 60, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 60, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 70, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 70, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


    
  TestCommandBegin(__eDiagService, __cDiagService, "Read the Coded Temperatures", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse DMRL_MMA.* __resp;
    DiagRequest DMRL_MMA.WL_Thermal_Protection_VariantCoding_Read __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel("DMRL_MMA", EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp("DMRL_MMA", __req, __resp, __res, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 50, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG1\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 50, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 60, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG2\'");
        snprintf(__cArray2, 8192, "%s", __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        __ReportTableRow(0, __cArray2, "==", 60, __cArray3);
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
      
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3", __nDiagValue);
        __csr = CheckSignalMatch(__nDiagValue, 70, "==") == 1;
        snprintf(__cArray, 8192, "%s", "Diagnostic parameter \'WL_Thermal_Protection_VariantCoding/PPWC_SWTS_ASG3\'");
