      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc88_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc89()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc89", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window closing interrupted afterrun inactive [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc89()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc89_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_3_2_Disable_VSL_Living", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0e733b83-0031-415b-a65b-a0f97dea50ce");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 58 s", "4");
  {
    __Wait("1", (58 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Closing", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Open Front Right Door", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Afterrun is deactivated after timeout. All windows stop moving immediately", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "10");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc89_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_3_1_Enable_VSL_Living", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3b880703-c0fa-4b27-bf3d-b0f22e9e21b4");
    }


    TestCommandBegin(__eSet, __cSet, "Close Front Right Door", "14");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc90()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc90", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Window interrupted by driver control [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc90()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc90_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Passenger Window start Closing", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Close Button for Front Windows", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "7");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Passenger Window Stop moving immediately", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button for Front Windows", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "12");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows RL and RR start Closing", "16");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Close Button for Rear Windows", "19");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 2;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANCLS");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "20");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANCLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "21");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows RL and RR Stop moving immediately", "22");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Close Button for Rear Windows", "24");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "26");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  TestCommandBegin(__eCheck, __cCheck, "Windows RL and RR remains in Same Position", "28");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc90_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc91()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc91", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Child security lock activation deactivation [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc91()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc91_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_13_1_Child_Security_Lock_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9dc4d60c-f737-4f9c-bd61-d2b416d76160");
  }


  TestCommandBegin(__eCheck, __cCheck, "Rear Windows do not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Rear Windows do not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "804492b6-9f3d-4fb1-8bfa-7cbc3cf1c35d");
  }


  TestCommandBegin(__eCheck, __cCheck, "Rear Windows start Opening", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Rear Windows Opens Completely", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc91_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc92()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc92", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Child security lock activation, deactivation - emergency mode [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc92()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc92_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "804492b6-9f3d-4fb1-8bfa-7cbc3cf1c35d");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eSet, __cSet, "Activate CSL", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35.phys = 1;
      snprintf(__cArray, 8192, "%s", "CSL_Inact_ST35");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_FLS_TRU_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "No signals are sent as CEIC is disconnected", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "CSL_LHD_Inact_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Deactivate CSL", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35.phys = 2;
      snprintf(__cArray, 8192, "%s", "CSL_Inact_ST35");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_FLS_TRU_TRUE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`CEIC_M_BODY1_Container_ST3_PW_Settings_ST35::`CSL_Inact_ST35, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "No signals are sent as CEIC is disconnected", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "CSL_LHD_Inact_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`CSL_LHD_Inact_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }



}

void Ttcc5jmo2_Tet_Tc92_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "804492b6-9f3d-4fb1-8bfa-7cbc3cf1c35d");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc93()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc93", __eTcDef, __eLocal);  
  CallInterfaceFunction("Code Manual Recirculation", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc93()
{	
  SetBreakOnFail(1);

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2679cc2d-60ab-4943-88d0-8c66e1695bf3");
  }


}

void Ttcc5jmo2_Tet_Tc94()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc94", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Manual window closing stops by button release [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc94()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc94_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(50);
    AddIFParameterInt64(20);
    AddIFParameterInt64(30);
    AddIFParameterInt64(40);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "10");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows stop when saved window position is reached", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 45, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 55, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(45, 55, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 12, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 25, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(12, 25, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 25, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 35, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(25, 35, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 35, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 45, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(35, 45, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "13");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc94_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_10_3_Windows_Disable_Recirculation_Request", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "9c43fce0-fdba-4ad0-9680-1db2e0be3bf3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc95()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc95", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Manual window closing stops by windows closed [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc95()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc95_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(50);
    AddIFParameterInt64(20);
    AddIFParameterInt64(30);
    AddIFParameterInt64(40);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows Closes Completely", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows do not move , stay in Closed State", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows do not move , stay in Closed State", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "14");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows stop when saved window position is reached", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 45, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 55, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(45, 55, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 12, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 25, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(12, 25, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 25, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 35, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(25, 35, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 35, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 45, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(35, 45, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "16");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "17");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc95_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_10_3_Windows_Disable_Recirculation_Request", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "9c43fce0-fdba-4ad0-9680-1db2e0be3bf3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc96()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc96", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Manual window closing stops by button release, window position near short stroke position [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc96()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc96_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(9);
    AddIFParameterInt64(9);
    AddIFParameterInt64(9);
    AddIFParameterInt64(9);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "10");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows stop when saved window position is reached", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 6, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 12, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(6, 12, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 6, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 12, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(6, 12, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 6, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 12, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(6, 12, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 6, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 12, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(6, 12, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "13");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc96_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_10_3_Windows_Disable_Recirculation_Request", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "9c43fce0-fdba-4ad0-9680-1db2e0be3bf3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc97()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc97", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_No manual window closing when not coded [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc97()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc97_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. They do not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. remain in Open Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc97_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "2679cc2d-60ab-4943-88d0-8c66e1695bf3");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc98()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc98", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_No manual window closing when window near closed [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc98()
{	
  SetBreakOnFail(1);

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(4);
    AddIFParameterInt64(4);
    AddIFParameterInt64(4);
    AddIFParameterInt64(4);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. They do not move. Stay in already defined Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. remain in Same intermediate Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_Tet_Tc99()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc99", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_No manual window closing when window position smaller than short stroke position [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc99()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc99_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  TestCommandBegin(__eSet, __cSet, "Open Front Doors", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. They do not move. Stay in already defined Position", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. remain in same intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc99_Completion()
{  
  TestCompletionBegin();
  {
    TestCommandBegin(__eSet, __cSet, "Close all Doors", "8");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_RL_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_RR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc100()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc100", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_No manual window closing when vehicle state parking [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc100()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc100_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. They do not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. remain in Open Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc100_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
      AddIFParameterInt64(2);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc101()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc101", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Manual recirculation closing interrupted by timeout of the HVAC recirculation message [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc101()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc101_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc101_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc102()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc102", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Manual recirculation closing interrupted by higher priority request [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc102()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc102_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for Front Windows", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Front windows stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for Rear Windows", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Rear windows stop immediately", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "12");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc102_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc103()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc103", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Manual recirculation closing interrupted by windows denormed [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc103()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc103_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc103_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_4_2_Normalization_Of_Windows", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "fa43c794-a25b-464f-a0fd-054c6c96e551");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc104()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc104", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Manual recirculation closing interrupted by undervoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc104()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc104_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_1_Set_Under_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f4589989-93b4-4e85-98a7-5db802bde37a");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc104_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc105()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc105", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Manual recirculation closing interrupted by overvoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc105()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc105_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_2_Set_Over_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b30d40b0-14c6-4a28-8219-c77680f72ca4");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc105_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc106()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc106", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Manual recirculation closing interrupted by IGN_OFF [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc106()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc106_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc106_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc107()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc107", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_07_Manual recirculation closing interrupted by IGN_START [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc107()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc107_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(5);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc107_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc108()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc108", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_08_Manual recirculation closing interrupted by remote start active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc108()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc108_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc108_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc109()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc109", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_09_Automatic recirculation closing interrupted by short stroke by CT active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc109()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc109_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_1_WL_Front_Disabled_or_SS_Front_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ae9024c2-1fe7-444d-9504-935f3f2f281e");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Front windows stop immediately. Rear continue to Close", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_3_WL_Rear_Disabled_or_SS_Rear_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "53af52eb-3369-488e-bbd8-a44e64cfa7a1");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Rear windows also stop immediately", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc109_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_2_WL_Front_Enabled_or_SS_Front_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "36ebd0ff-570b-46d0-8c57-033245289cc9");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_4_WL_Rear_Enabled_or_SS_Rear_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "a1b9162c-2edb-4499-a69b-dff2415b4db3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc110()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc110", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Multiple recirculation request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc110()
{	
  SetBreakOnFail(1);

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "16");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "17");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows close if close position is reached", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "21");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "22");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows Open Completely", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "24");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Open", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_Tet_Tc111()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc111", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Recirculation closing position deleted [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc111()
{	
  SetBreakOnFail(1);

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_Tet_Tc112()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc112", __eTcDef, __eLocal);  
  CallInterfaceFunction("Code Automatic Recirculation", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc112()
{	
  SetBreakOnFail(1);

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


}

void Ttcc5jmo2_Tet_Tc113()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc113", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Windows close [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc113()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc113_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc113_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc114()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc114", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Automatic window closing stops by windows closed [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc114()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc114_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(50);
    AddIFParameterInt64(20);
    AddIFParameterInt64(30);
    AddIFParameterInt64(40);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "All windows stop when closed position is reached", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remain in Closed Position", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_4_Windows_AUT_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "647ff624-8ae5-459e-a8c4-745dad2d485d");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "13");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows stop when saved window position is reached", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 45, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 55, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(45, 55, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 12, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 25, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(12, 25, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 25, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 35, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(25, 35, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 35, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 45, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(35, 45, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "16");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "17");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc114_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc115()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc115", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Automatic recirculation closing enabled window position smaller than the short stroke position all doors closed [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc115()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc115_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    AddIFParameterInt64(14);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows Closes completely", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc115_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc116()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc116", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window position is not deleted by change of IGN status [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc116()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc116_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows Closes completely", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows do not move", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(4);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows do not move", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_4_Windows_AUT_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "647ff624-8ae5-459e-a8c4-745dad2d485d");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc116_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc117()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc117", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_No automatic recirculation closing when fault active [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc117()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc117_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_23_1_Change_Body_Style_Fault_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0b946691-cc97-4700-ac8f-1c154401eb6d");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_4_Windows_AUT_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "647ff624-8ae5-459e-a8c4-745dad2d485d");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position.Windows remain in Open Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc117_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_23_2_Default_Body_Style_Fault_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "19dc18e8-670d-487a-bfb8-e9e48fe96ec5");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc118()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc118", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_No automatic recirculation closing when diagnostics disabled [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc118()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc118_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2679cc2d-60ab-4943-88d0-8c66e1695bf3");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_4_Windows_AUT_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "647ff624-8ae5-459e-a8c4-745dad2d485d");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position.Windows remain in Open Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc118_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc119()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc119", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_No automatic recirculation closing when window position too small [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc119()
{	
  SetBreakOnFail(1);

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(5);
    AddIFParameterInt64(5);
    AddIFParameterInt64(5);
    AddIFParameterInt64(5);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


}

void Ttcc5jmo2_Tet_Tc120()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc120", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_No automatic recirculation closing when window position smaller than the short stroke position [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc120()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc120_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(8);
    AddIFParameterInt64(8);
    AddIFParameterInt64(8);
    AddIFParameterInt64(8);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  TestCommandBegin(__eSet, __cSet, "Open Front Doors", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_RR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


