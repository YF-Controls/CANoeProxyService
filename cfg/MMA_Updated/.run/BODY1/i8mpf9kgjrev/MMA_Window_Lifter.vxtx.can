      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "16");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "17");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "18");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Start Moving / Opening", "19");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "21");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows stop immediately", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "24");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "26");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows remain in Intermediate Position", "27");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc19_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc20()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc20", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window opening interrupted afterrun inactive [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc20()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc20_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_3_2_Disable_VSL_Living", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0e733b83-0031-415b-a65b-a0f97dea50ce");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 58 s", "4");
  {
    __Wait("1", (58 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "8");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows Start Moving / Opening", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Afterrun is deactivated after timeout. Front windows stop moving immediately,", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "13");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows remain in Intermediate Position", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(4);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 58 s", "19");
  {
    __Wait("1", (58 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "22");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "24");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Start Moving / Opening", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Afterrun is deactivated after timeout. Rear windows stop moving immediately,", "26");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "27");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "28");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "29");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows remain in Intermediate Position", "30");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc20_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc21()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc21", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Window opening interrupted window opened [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc21()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc21_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "4");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows Start Moving / Opening", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Front moving windows stop when open position is reached", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "10");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows remain in Open Position", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "14");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "16");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Start Moving / Opening", "17");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "18");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Rear moving windows stop when open position is reached", "19");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "20");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "21");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "22");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows remain in Open Position", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc21_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc22()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc22", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Windows manual opening interrupted and disabled - send vehicle State not valid [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc22()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc22_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "2");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "4");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows Start Moving/Opening", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Open Driver\'s Door", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(10);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows Still Moving/Opening", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows Stop in Intermediate Position", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Close Open for Front Windows", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "13");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows remians in Intermediate Position", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "15");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "16");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "17");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows remians in Intermediate Position", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Close Driver\'s Door", "20");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "24");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "26");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Start moving / Opening", "27");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Open Driver\'s Door", "28");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(10);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Still moving /Opening", "30");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Stop in Intermediate Position", "32");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "33");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "34");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "35");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows Stop in Intermediate Position", "36");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "39");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "40");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "41");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows remain in Intermediate Position", "42");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc22_Completion()
{  
  TestCompletionBegin();
  {
    TestCommandBegin(__eSet, __cSet, "Close Driver\'s Door", "44");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_11_Vehicle_state", __eFct, __eLocal);
      AddIFParameterInt64(2);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3e43138f-ab6a-4959-b80b-2c36b3bb5a95");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc23()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc23", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Button released window stops [EB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc23()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc23_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


    TestCommandBegin(__eWait, __cWait, "Wait 3 s", "1");
    {
      __Wait("1", (3 * 1000000000LL), 1000000000, "");
    }
    TestCommandEnd();

    TestCommandBegin(__eCheck, __cCheck, "Check if the Windows are in Closed State", "2");
    {
      __bVerdict = __eVerdictPass;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __ePassFail);
    
        __bVerdict = __bVerdict && __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __ePassFail);
    
        __bVerdict = __bVerdict && __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __ePassFail);
    
        __bVerdict = __bVerdict && __csr;
      }
      {
        __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
        __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
        __ReportCell(__cArray5);
        __ReportCellResult(__csr, __ePassFail);
    
        __bVerdict = __bVerdict && __csr;
      }
      __ReportTableEndVerdict("1", __bVerdict);
    }
    TestCommandEnd();


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows Start moving immediately except Front Left", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows Stop moving immediately except Front Left", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc23_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc24()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc24", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Window opening by denormed window [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc24()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc24_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "2");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows except Front Left Window", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc24_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_4_2_Normalization_Of_Windows", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "fa43c794-a25b-464f-a0fd-054c6c96e551");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc25()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc25", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Window opens emergency mode active [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc25()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc25_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "3");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows except Front Left Window", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc25_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc26()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc26", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Window does not move when key is outside [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc26()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc26_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_12_Key_State", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "df932d2d-0ec0-41bb-9c8d-56a8fd111b8f");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc26_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_12_Key_State", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "df932d2d-0ec0-41bb-9c8d-56a8fd111b8f");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc27()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc27", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Window does not move when afterrun is inactive [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc27()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc27_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_3_2_Disable_VSL_Living", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0e733b83-0031-415b-a65b-a0f97dea50ce");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "7");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc27_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_3_1_Enable_VSL_Living", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3b880703-c0fa-4b27-bf3d-b0f22e9e21b4");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc28()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc28", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Window does not move when remote start is active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc28()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc28_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc28_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc29()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc29", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window does not move undervoltage [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc29()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc29_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_1_Set_Under_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f4589989-93b4-4e85-98a7-5db802bde37a");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc29_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc30()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc30", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Window does not move overvoltage [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc30()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc30_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_2_Set_Over_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b30d40b0-14c6-4a28-8219-c77680f72ca4");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc30_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc31()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc31", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Window does not move engine start [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc31()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc31_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_21_Precondition_for_Ign_Start_Cases", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34cfd5e9-d0c6-4bb6-857f-2f3faf8a0a5c");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(5);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "6");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows do not move. Remain in Closed Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc31_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc32()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc32", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_07_Window does not move CSL active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc32()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc32_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_13_1_Child_Security_Lock_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9dc4d60c-f737-4f9c-bd61-d2b416d76160");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows do not move. Remain in Closed Position. Passenger Window start opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows do not move. Remain in Closed Position. Passenger Window Opens Completely", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc32_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "804492b6-9f3d-4fb1-8bfa-7cbc3cf1c35d");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc33()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc33", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_08_Window does not move WL_front_disabled [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc33()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc33_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_1_WL_Front_Disabled_or_SS_Front_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ae9024c2-1fe7-444d-9504-935f3f2f281e");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows do not move. Remain in Closed Position. Rear Windows start opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Front Windows do not move. Remain in Closed Position. Rear Windows stops in Intermediate Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc33_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_2_WL_Front_Enabled_or_SS_Front_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "36ebd0ff-570b-46d0-8c57-033245289cc9");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc34()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc34", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_09_Window does not move short stroke request rear active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc34()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc34_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_3_WL_Rear_Disabled_or_SS_Rear_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "53af52eb-3369-488e-bbd8-a44e64cfa7a1");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows do not move. Remain in Closed Position. Passenger Windows start opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Windows do not move. Remain in Closed Position. Passenger Window stops in Intermediate Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc34_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_4_WL_Rear_Enabled_or_SS_Rear_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "a1b9162c-2edb-4499-a69b-dff2415b4db3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc35()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc35", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_10_Window do not move temperature protection active - Passenger [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc35()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc35_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_3_FR_Thermal_Protection", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b545d090-ff7c-480b-9d66-c82a3a6fde00");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Passenger Window do not move. Remain in Closed Position. ", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Passenger Window do not move. Remain in Closed Position.", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc35_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_7_ALL_DEACT_Thermal_Protection", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "534b9226-ac25-4dfc-bcc0-b922dd44d940");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc36()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc36", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_11_Window do not move temperature protection active - RL [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc36()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc36_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_3_RL_Thermal_Protection", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1b6e1ac3-a2f0-4e08-b169-e148e6ffc876");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Left Window do not move. Remain in Closed Position. ", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Left Window do not move. Remain in Closed Position.", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc36_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_7_ALL_DEACT_Thermal_Protection", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "534b9226-ac25-4dfc-bcc0-b922dd44d940");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc37()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc37", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_12_Window do not move temperature protection active - RR [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc37()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc37_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_3_RR_Thermal_Protection", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4d50ac40-67aa-43f8-85b6-c82827febb4f");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Right Window do not move. Remain in Closed Position. ", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Rear Right Window do not move. Remain in Closed Position.", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc37_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_7_ALL_DEACT_Thermal_Protection", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "534b9226-ac25-4dfc-bcc0-b922dd44d940");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc38()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc38", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Window opening interrupted remote start active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc38()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc38_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Opening", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Windows P, RL and RR Stop moving immediately", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc38_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc39()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc39", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Window manual opening interrupted, wrong ignition state - IGN_LOCK [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc39()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc39_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Opening", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Windows P, RL and RR Stop moving immediately", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc39_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc40()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc40", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Window manual opening interrupted, wrong ignition state - IGN_OFF [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc40()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc40_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Opening", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Windows P, RL and RR Stop moving immediately", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "6");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc40_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc41()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc41", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window opening interrupted afterrun inactive [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc41()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc41_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_3_2_Disable_VSL_Living", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0e733b83-0031-415b-a65b-a0f97dea50ce");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 58 s", "4");
  {
    __Wait("1", (58 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Opening", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Open Front Right Door", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 2;
      snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_OPN");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Afterrun is deactivated after timeout. All windows stop moving immediately", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "10");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc41_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_3_1_Enable_VSL_Living", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3b880703-c0fa-4b27-bf3d-b0f22e9e21b4");
    }


    TestCommandBegin(__eSet, __cSet, "Close Front Right Door", "14");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc42()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc42", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Window opening interrupted window opened [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc42()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc42_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows P, RL and RR start Opening", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (5 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows P, RL and RR Stop moving after Open position is reached", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "7");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc42_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc43()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc43", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Window interrupted by driver control [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc43()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc43_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the Passenger Window start Opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "7");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Passenger Window Stop moving immediately", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 2 s", "12");
  {
    __Wait("1", (2 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check that the Windows RL and RR start Opening", "16");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "19");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "20");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "21");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows RL and RR Stop moving immediately", "22");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "24");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "25");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "26");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that the windows remain is same position", "28");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc43_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc44()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc44", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Window opens emergency mode active CSL active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc44()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc44_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_13_1_Child_Security_Lock_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9dc4d60c-f737-4f9c-bd61-d2b416d76160");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "7");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "9");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "13");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc44_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_13_0_Child_Security_Lock_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "804492b6-9f3d-4fb1-8bfa-7cbc3cf1c35d");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc45()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc45", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Window opens emergency mode active key not detected [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc45()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc45_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_17_2_Deactivate_Key_Search", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b749aff5-5ae5-426d-9e15-c07250ef677b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "6");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "8");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "15");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "16");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "17");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "19");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "20");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "21");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "22");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "23");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "24");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc45_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_17_1_Activate_Key_Search", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "2002c960-7004-4b82-8877-a8571c219dd9");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc46()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc46", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Window opens emergency mode active no interruption [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc46()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc46_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "9");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "17");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "19");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "20");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "22");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_RUNNING");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "23");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "24");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "25");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "26");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "27");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "28");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc46_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc47()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc47", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Window opens emergency mode active no interruption afterrun inactive [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc47()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc47_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "10");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Front Windows Continue to Open ", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "12");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(4);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "21");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "22");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "23");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "24");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_13_Set_AfterRun_Inactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4564fc41-6670-428f-87ca-fab768bf19ad");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "28");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Rear Windows continue to Open", "29");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "30");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "31");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "32");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "33");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc47_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc48()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc48", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Window opens emergency mode active no interruption remote start active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc48()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc48_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Front Windows", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "5");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "9");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Front Windows Continue to Open ", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Front Windows", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows ", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press and Hold Manual Open Button for Rear Windows", "20");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "MANOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "21");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_MANOPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "22");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "26");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Rear Windows continue to Open", "27");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Release Manual Open Button for Rear Windows", "28");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 0;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "NPSD");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 0, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Released", "29");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_NPSD");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "30");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Rear Windows", "31");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }



}

void Ttcc5jmo2_Tet_Tc48_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_16_2_Emergency_Mode_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "1fd08a7d-7c0a-42c6-a48d-da3c582c4d54");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc49()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc49", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Window opens emergency mode active no interruption CSL active [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc49()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc49_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_16_1_Emergency_Mode_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "73766515-23bb-4b96-bebe-2edd700de46b");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "3");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows except Front Left Window", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Position of Front Left Window", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_13_1_Child_Security_Lock_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9dc4d60c-f737-4f9c-bd61-d2b416d76160");
  }


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "8");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check the Position of All the Windows except Front Left Window", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
