  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc120_Completion()
{  
  TestCompletionBegin();
  {
    TestCommandBegin(__eSet, __cSet, "Close Front Doors", "7");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FL_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FL_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_FR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_FR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_RL_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RL_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3.phys = 1;
        snprintf(__cArray, 8192, "%s", "DrRLtch_RR_Stat_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_DR_STAT_CLS");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_GW_Container_ST3_CLkS_Dr_State_ST3::`DrRLtch_RR_Stat_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc121()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc121", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_No automatic recirculation closing when IGN_ACC [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc121()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc121_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc121_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc122()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc122", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_No automatic recirculation closing when IGN_OFF [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc122()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc122_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc122_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc123()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc123", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when IGN_LOCK [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc123()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc123_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(0);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc123_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc124()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc124", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when remote start active [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc124()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc124_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc124_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc125()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc125", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when windows denormed [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc125()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc125_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc125_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc126()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc126", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when undervoltage [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc126()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc126_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_2_Precondition_for_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "70c13fc2-8a44-4e62-8dc6-8d26fa16f73a");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_1_Set_Under_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f4589989-93b4-4e85-98a7-5db802bde37a");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows does not move", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc126_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc127()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc127", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when overvoltage [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc127()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc128()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc128", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when engine start active [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc128()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc129()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc129", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when short stroke position front is requested by CT [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc129()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc130()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc130", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when short stroke position rear is requested by CT [FVoB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc130()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc131()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc131", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when thermal protection active [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc131()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc132()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc132", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic recirculation closing when vehicle state not enabled for window function [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc132()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc133()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc133", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by exceeding the zero point [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc133()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc134()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc134", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by short stroke [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc134()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc135()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc135", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by recirculation opening [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc135()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc136()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc136", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by higher priority request [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc136()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc137()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc137", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by vehicle state [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc137()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc138()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc138", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by IGN_OFF [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc138()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc139()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc139", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by IGN_LOCK [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc139()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc140()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc140", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by engine start [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc140()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc141()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc141", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by remote start active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc141()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc142()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc142", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by windows denormed [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc142()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc143()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc143", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by undervoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc143()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc144()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc144", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by overvoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc144()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc145()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc145", __eTcDef, __eLocal);  
  CallInterfaceFunction("Automatic recirculation closing interrupted by short stroke by CT active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc145()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc146()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc146", __eTcDef, __eLocal);  
  CallInterfaceFunction("Second recirculation request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc146()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc147()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc147", __eTcDef, __eLocal);  
  CallInterfaceFunction("Recirculation closing position deleted [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc147()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc148()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc148", __eTcDef, __eLocal);  
  CallInterfaceFunction("Recirculation opening interrupted immediately by recirculation closing [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc148()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc149()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc149", __eTcDef, __eLocal);  
  CallInterfaceFunction("Code Manual Recirculation", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc149()
{	
  SetBreakOnFail(1);

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2679cc2d-60ab-4943-88d0-8c66e1695bf3");
  }


}

void Ttcc5jmo2_Tet_Tc150()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc150", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Windows open [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc150()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc150_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "4");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows Opens Completely", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Open Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc150_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc151()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc151", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Recirculation button released [EB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc151()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc151_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 1 s", "4");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stop moving immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc151_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc152()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc152", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Recirculation position reached [EB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc152()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc152_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(200);
    AddIFParameterInt64(200);
    AddIFParameterInt64(200);
    AddIFParameterInt64(200);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 3 s", "10");
  {
    __Wait("1", (3 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Windows stop when saved window position is reached", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 198, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, 203, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(198, 203, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 198, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, 203, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_FR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(198, 203, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 198, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, 203, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RL_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(198, 203, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      {
        int __res1,__res2;
        __res1 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 198, __cGreaterEqualThan) == 1;
        __res2 = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, 203, __cLessEqualThan) == 1;
        __csr = __res1 && __res2;
        snprintf(__cArray, 8192, "%s", "PW_RR_Posn_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "");
        snprintf(__cArray4, 8192, "%s", "");
        snprintf(__cArray5, 8192, "%s", __cArray3);
        snprintf(__cArray6, 8192, "%s", __cArray4);
        ReportRange(198, 203, __cArray5, __cArray6, __cArray7, 8192);
        __ReportTableRow(0, __cArray2, __cRange, __cArray7, __cEmpty);
        __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_ST3, __cArray8);
        __ReportCell(__cArray8);
        __ReportCellResult(__csr, __ePassFail);
      }
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "13");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "14");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc152_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_10_3_Windows_Disable_Recirculation_Request", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "9c43fce0-fdba-4ad0-9680-1db2e0be3bf3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_1_Power_Windows_Open", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "8107aae2-4b9d-4b1f-8dc2-f44bd9fe3be2");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc153()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc153", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_No manual recirculation opening when diagnostics disabled [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc153()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc153_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_4_1_Code_Automatic_Recirculation", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "62493126-2814-4621-8694-1d145b5c3f0b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window does not move", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "5");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows remain in closed Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Close Position", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 2, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLS");
      __ReportTableRow(0, __cArray2, "==", 2, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc153_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_4_0_Code_Manual_Recirculation", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "2679cc2d-60ab-4943-88d0-8c66e1695bf3");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc154()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc154", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_No manual recirculation opening when no recirculation position saved [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc154()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc154_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_22_Set_Window_Position_for_Recirculation_Cases", __eFct, __eLocal);
    AddIFParameterInt64(50);
    AddIFParameterInt64(20);
    AddIFParameterInt64(30);
    AddIFParameterInt64(40);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8ece929c-3970-40fa-b1f7-0cf2f91ba71b");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window does not move. Remain in already defined state", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "6");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows remain in intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in intermediate Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc154_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_4_2_Normalization_Of_Windows", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "fa43c794-a25b-464f-a0fd-054c6c96e551");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc155()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc155", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Recirculation opening interrupted by timeout of the HVAC recirculation message [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc155()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc155_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending local HVAC message Signals", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FR_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FR_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FR_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_RL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RR_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_RR_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RR_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc155_Completion()
{  
  TestCompletionBegin();
  {
    TestCommandBegin(__eSet, __cSet, "Start sending local HVAC message Signals", "8");
    {
      __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 2;
        snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FR_Rq_HVAC_ST3.phys = 2;
        snprintf(__cArray, 8192, "%s", "CC_Win_FR_Rq_HVAC_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FR_Rq_HVAC_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RL_Rq_HVAC_ST3.phys = 2;
        snprintf(__cArray, 8192, "%s", "CC_Win_RL_Rq_HVAC_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RL_Rq_HVAC_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
        
    
      }
      {
        $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RR_Rq_HVAC_ST3.phys = 2;
        snprintf(__cArray, 8192, "%s", "CC_Win_RR_Rq_HVAC_ST3");
        snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
        snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_TRUE");
        
        __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_RR_Rq_HVAC_ST3, __cArray2, __cArray4);
        __ReportTableRow(0, __cArray4, __cAOp, 2, __cArray3);
        
    
      }
      __ReportTableEndTestStep("1");
    }
    TestCommandEnd();


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc156()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc156", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Recirculation opening interrupted by higher priority request [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc156()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc156_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for Front Windows", "4");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_FR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_FR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_FR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Front windows stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_1_Select_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1ff14b53-bc07-4b94-bf08-9392799f1b90");
  }


  TestCommandBegin(__eSet, __cSet, "Press Auto Open Button for Rear Windows", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RL_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    {
      $`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR.phys = 5;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_ST3_DOOR");
      snprintf(__cArray2, 8192, "%s '%s'", __cLinSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "AUTOOPN");
      
      __ReportSetLValueOrSignalNotOnline(`LIN::dbNode::`DSM_WM_DOOR::`DSM_WM_Stat_LIN_ST3_DOOR::`PW_Adj_RR_ST3_DOOR, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 5, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check the Response signal for Button Pressed", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RL_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RL_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, 5, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_Adj_RR_Dr_FL_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C03_NPSD_MAN_STP_AUTOPNCLS_IMP_AUTOOPN");
      __ReportTableRow(0, __cArray2, "==", 5, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container1_ST3_PW_Adj_Rq_Dr_FL_ST3::`PW_Adj_RR_Dr_FL_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Rear windows stop immediately", "10");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_12_2_Deselect_Rear_Button", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "330f839f-c2ed-4150-8fa2-4f59b8c964b4");
  }


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "12");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "13");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc156_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc157()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc157", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Recirculation opening interrupted by windows denormed [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc157()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc157_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_4_1_Denormalization_Of_Windows", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "587cc6a5-d2eb-42ea-b5ca-ef7a043f66b2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc157_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_4_2_Normalization_Of_Windows", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "fa43c794-a25b-464f-a0fd-054c6c96e551");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc158()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc158", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Recirculation opening interrupted by undervoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc158()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc158_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_1_Set_Under_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f4589989-93b4-4e85-98a7-5db802bde37a");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc158_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc159()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc159", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Recirculation opening interrupted by overvoltage [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc159()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc159_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_14_2_Set_Over_Voltage", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b30d40b0-14c6-4a28-8219-c77680f72ca4");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc159_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_14_3_Set_Normal_Voltage", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "daace6b6-4cd7-4d83-ac11-992b1a2e03c7");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc160()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc160", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Recirculation opening interrupted by IGN_OFF [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc160()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc160_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(1);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc160_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc161()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc161", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_07_Recirculation opening interrupted by remote start [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc161()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc161_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
    AddIFParameterInt64(2);
    CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "6");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc161_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_8_Remote_Start", __eFct, __eLocal);
      AddIFParameterInt64(1);
      CallInterfaceFunction(__cEmpty, __cEmpty, "eefb4b34-632a-40da-b6a2-43ae4500dae2");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc162()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc162", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_08_Recirculation opening interrupted by engine start [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc162()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc162_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_21_Precondition_for_Ign_Start_Cases", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "34cfd5e9-d0c6-4bb6-857f-2f3faf8a0a5c");
  }


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
    AddIFParameterInt64(5);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window stop immediately", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "7");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc162_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_10_Ignition_Status", __eFct, __eLocal);
      AddIFParameterInt64(4);
      CallInterfaceFunction(__cEmpty, __cEmpty, "ed53a2fd-4e1b-4fb7-beaa-9869a308d142");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc163()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc163", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_09_Automatic recirculation closing interrupted by short stroke by CT active [AB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc163()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc163_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check that Window start moving / opening", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_1_WL_Front_Disabled_or_SS_Front_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ae9024c2-1fe7-444d-9504-935f3f2f281e");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Front windows stop immediately", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_15_3_WL_Rear_Disabled_or_SS_Rear_Active", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "53af52eb-3369-488e-bbd8-a44e64cfa7a1");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Rear windows stop immediately", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "8");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Intermediate Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc163_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_2_WL_Front_Enabled_or_SS_Front_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "36ebd0ff-570b-46d0-8c57-033245289cc9");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_15_4_WL_Rear_Enabled_or_SS_Rear_Deactive", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "a1b9162c-2edb-4499-a69b-dff2415b4db3");
    }


    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc164()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc164", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Recirculation position stays saved [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc164()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc164_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_BS_18_1_Precondition_for_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "3059bec7-7af3-4e7c-be62-254a53a4a553");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "5");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "6");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "11");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows remian in same Position", "12");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "15");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "", "16");
  {
    __Wait("1", (1 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "17");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows Open if Open position is reached", "18");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc164_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc165()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc165", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Windows open [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc165()
{	
  SetBreakOnFail(1);

  CreateTTEIFFunction("Ttcc5jmo2_Tet_Tc165_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_1_Windows_MAN_CLS_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "e84ced27-cfff-4166-a812-e47aa14307c7");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 7, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_CLOSING");
      __ReportTableRow(0, __cArray2, "==", 7, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "3");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. All windows stop immediately", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 0, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_INTERMEDIATE");
      __ReportTableRow(0, __cArray2, "==", 0, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  {
    CreateTTEIFFunction("Ttcc5jmo2_BS_10_2_Windows_MAN_OPN_Recirculation_Request", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "2ed7df22-667a-43d9-a27f-e4150c138bdb");
  }


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position", "7");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 6, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPENING");
      __ReportTableRow(0, __cArray2, "==", 6, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eWait, __cWait, "Wait 4 s", "8");
  {
    __Wait("1", (4 * 1000000000LL), 1000000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows open", "9");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();


  TestCommandBegin(__eSet, __cSet, "Stop sending recirculation request", "10");
  {
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3.phys = 1;
      snprintf(__cArray, 8192, "%s", "CC_Win_FL_Rq_HVAC_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C02_NDEF_FALSE_TRUE_ST3_FALSE");
      
      __ReportSetLValueOrSignalNotOnline(`BODY1::dbNode::`CEIC_M::`BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::`CC_Win_FL_Rq_HVAC_ST3, __cArray2, __cArray4);
      __ReportTableRow(0, __cArray4, __cAOp, 1, __cArray3);
      
  
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();


  TestCommandBegin(__eCheck, __cCheck, "Check Window Position. Windows stay in Open Position", "11");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FL::`DM_FL_BODY1_Container2_ST3_PW_FL_Stat_ST3::`PW_FL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_FR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_FR::`DM_FR_BODY1_Container2_ST3_PW_FR_Stat_ST3::`PW_FR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RL_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RL::`DM_RL_BODY1_Container2_ST3_PW_RL_Stat_ST3::`PW_RL_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    {
      __csr = CheckSignalMatch(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, 1, "==") == 1;
      snprintf(__cArray, 8192, "%s", "PW_RR_Posn_Stat_ST3");
      snprintf(__cArray2, 8192, "%s '%s'", __cPduSignal, __cArray);
      snprintf(__cArray3, 8192, "%s", "I_C04_PW_POSN_STAT_ST3_WNDW_OPN");
      __ReportTableRow(0, __cArray2, "==", 1, __cArray3);
      __ReportLValueOrSignalNotOnline(`BODY1::dbNode::`DM_RR::`DM_RR_BODY1_Container2_ST3_PW_RR_Stat_ST3::`PW_RR_Posn_Stat_ST3, __cArray5);
      __ReportCell(__cArray5);
      __ReportCellResult(__csr, __ePassFail);
  
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();



}

void Ttcc5jmo2_Tet_Tc165_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttcc5jmo2_RC_1_0_Power_Windows_Close", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "0baf3fe2-ad68-4b04-aa3b-adcc5c58fd54");
    }


  }
  TestCompletionEnd();
}

void Ttcc5jmo2_Tet_Tc166()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc166", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_01_Automatic window opening FL by Online-Request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc166()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc167()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc167", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_02_Automatic window opening FR by Online-Request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc167()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc168()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc168", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_03_Automatic window opening RL by Online-Request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc168()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc169()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc169", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_04_Automatic window opening RR by Online-Request [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc169()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc170()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc170", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_05_Automatic window opening FL by Online-Request, no key search [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc170()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc171()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc171", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_06_Automatic window opening FR by Online-Request, no key search [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc171()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc172()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc172", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_07_Automatic window opening RL by Online-Request, no key search [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc172()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc173()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc173", __eTcDef, __eLocal);  
  CallInterfaceFunction("TC_08_Automatic window opening RL by Online-Request, no key search [FA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc173()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc174()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc174", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening when key not detected inside [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc174()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc175()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc175", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening when temperature protection active [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc175()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc176()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc176", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening when windows denormed [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc176()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc177()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc177", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening when overvoltage [FVoA]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc177()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc178()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc178", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening when windows completely open [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc178()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc179()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc179", __eTcDef, __eLocal);  
  CallInterfaceFunction("No automatic window opening for USA variant [VB]", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc179()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc180()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc180", __eTcDef, __eLocal);  
  CallInterfaceFunction("Test Case", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc180()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc181()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc181", __eTcDef, __eLocal);  
  CallInterfaceFunction("Test Case", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc181()
{	
  SetBreakOnFail(1);

}

void Ttcc5jmo2_Tet_Tc182()
{
  CreateTTEIFFunction("Ttcc5jmo2_Tc182", __eTcDef, __eLocal);  
  CallInterfaceFunction("Test Case", __cEmpty , __cEmpty );
}
testcase Ttcc5jmo2_Tc182()
{	
  SetBreakOnFail(1);

}

