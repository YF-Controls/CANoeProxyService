includes
{
  // Import required CAPL include files
  //--- begin generated part --- Block start #GlobalBody_Includes#; do not delete this line and do not add application code in this code block!
  /* #ChannelGlobalStart# |CAN1| #BusGlobalStart# |BODY1| */
  #include "..\CAPL\ARGTMgr.cin"
  /* #ChannelGlobalEnd# |CAN1| #BusGlobalEnd# |BODY1| */
  //--- end generated part --- Block end #GlobalBody_Includes#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_Includes#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  #include "..\CAPL\PDU-IL-KL30-Helper_CAN1.cin"
  #include "..\CAPL\PDU-NM-Panel-Helper_CAN1.cin"
  #include "..\CAPL\PDU-NM-ASR-Helper_CAN1.cin"
  #include "..\CAPL\ARGT_CAN1.cin"
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Includes#; do not delete this line! Add application code below this line.
}

variables
{
  // Define global variables for this CAPL file

  /*--- #GenHeader Begin# --- begin generated comment ---
  | Generated on Tuesday, June 21, 2022, 17:40:32
  | By ModelGenerator for Daimler 1.5.4.10, ModelGeneratorDaimlerDLL 1.5.4.84
  | Package Daimler 4.1.0
  | Target Bus: BODY1; Channel: CAN1; DB Cluster: BODY1;
  | From Database: STAR_3_BODY1_CAN_2022_17b_AR43.arxml
  | CANoe Version 15.5.23.0
    --- #GenHeader End  # --- end generated comment --- */

  char gECU[256] = "BC_F";
  //--- begin generated part --- Block start #Hdr_GlobalVariables#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  // For AUTOSAR Global Time
  const word cARGTCAN1_DomainIdx_0              = 0; // administrative handle [0 - cARGTMgr_DomainCount-1] (global parameter; unique over all busses)
  const word cARGTCAN1_DomainID_0               = 0; // Global Time Domain ID (global parameter)
  char cARGTCAN1_DomainName_0[256]              = "GTD_BODY1_0"; // Global Time Domain Name (global parameter)
  const word cARGTCAN1_ChannelIdx_0             = 0; // administrative handle [0 - cARGTCAN1_MaxChannels-1] (bus local parameter)
  const dword cARGTCAN1_CAN_ID_0                = 0x79; // CAN identifier of the Global Time message
  // For BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3
  msTimer gCAN1TimerDateTime;
  int gCAN1_DateTime_Init = 1;
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  long  gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  dword gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  qword gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness; // for SecOC Freshness disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  long  gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  dword gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  qword gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo; // for SecOC AuthInfo disturbance of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_GlobalVariables#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #GlobalBody_GlobalVariables#; do not delete this line and do not add application code in this code block!
  /* #ChannelGlobalStart# |CAN1| #BusGlobalStart# |BODY1| */
  /* #ChannelGlobalEnd# |CAN1| #BusGlobalEnd# |BODY1| */
  //--- end generated part --- Block end #GlobalBody_GlobalVariables#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_GlobalVariables#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  char gCAN1BusName[256] = "BODY1";
  int gCAN1Channel = 1; //// The channel the bus is attached to

  long gCAN1DisturbanceMode;
  long gCAN1DisturbanceCount;
  long gCAN1DisturbanceValue;
  long gCAN1DisturbanceContinueMode;
  double gCAN1DisturbancePeriod;
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_GlobalVariables#; do not delete this line! Add application code below this line.
}

on preStart
{
  // Initialize CAPL includes and node's modules/DLLs
  //--- begin generated part --- Block start #Hdr_OnInit#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnInit#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #GlobalBody_OnInit#; do not delete this line and do not add application code in this code block!
  /* #ChannelGlobalStart# |CAN1| #BusGlobalStart# |BODY1| */
  ARGTMgr_OnInit();
  /* #ChannelGlobalEnd# |CAN1| #BusGlobalEnd# |BODY1| */
  //--- end generated part --- Block end #GlobalBody_OnInit#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnInit#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  ILCAN1_OnInit();
  NMCAN1_OnInit();
  ARGTMgr_InitTimeDomain( cARGTCAN1_DomainIdx_0,
    cARGTCAN1_DomainName_0,
    cARGTCAN1_DomainID_0,
    1750, // Sync Loss Timeout [ms]
    0, // Sync Loss Threshold [ms]
    0 /* Verbosity Level */ );
  ARGTCAN1_OnInit();
  ARGTCAN1_Init( cARGTCAN1_ChannelIdx_0,
    cARGTCAN1_DomainIdx_0,
    eARGTMgr_TimeGatewayMaster, // Role
    eARGTMgr_CRC_PROTECTED, // TX CRC Mode
    eARGTMgr_CRC_VALIDATED, // RX CRC Handling
    gCAN1Channel,
    cARGTCAN1_CAN_ID_0, // CAN ID
    1, // Is CAN-FD frame?
    1, // Baudrate switch for CAN-FD frame
    1, // Extended Data Length switch for CAN-FD frame
    500, // Sync period [ms]
    200, // Sync confirmation timeout [ms]
    40, // Follow-up offset [ms]
    250, // Follow-up timeout [ms]
    3, // Sequence Counter Jump Width [#]
    0, // Hardware Correction Threshold [ms]
    0 /* Verbosity Level */ );
  ARGTCAN1_SetUserBytesLength( cARGTCAN1_ChannelIdx_0, 1);
  ARGTCAN1_SetUserByte( cARGTCAN1_ChannelIdx_0, 0, 0);
  SetBusContext(gILCAN1_BusContext);
  ILSetOperationMode(0, @sysvar::IL::UBPlugNPlay);
  // For BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3, 2, 0); // set NWM-WakeupAllowed to false
  ILSetOperationMode(BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmStat_ST3, 2, 0); // set NWM-WakeupAllowed to false
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnInit#; do not delete this line! Add application code below this line.
}

on start
{
  // Start CAPL includes and node's modules/DLLs
  //--- begin generated part --- Block start #Hdr_OnStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnStart#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #GlobalBody_OnStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelGlobalStart# |CAN1| #BusGlobalStart# |BODY1| */
  ARGTMgr_OnStart();
  /* #ChannelGlobalEnd# |CAN1| #BusGlobalEnd# |BODY1| */
  //--- end generated part --- Block end #GlobalBody_OnStart#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  ILCAN1_OnStart();
  NMCAN1_OnStart();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnStart#; do not delete this line! Add application code below this line.
}

on preStop
{
  // Prepare stopping
  //--- begin generated part --- Block start #Hdr_OnStopping#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnStopping#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnStopping#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnStopping#; do not delete this line! Add application code below this line.
}

on stopMeasurement
{
  // Stop actions
  //--- begin generated part --- Block start #Hdr_OnStop#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnStop#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnStop#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnStop#; do not delete this line! Add application code below this line.
}

void StartSim(dword busContext, int busActive, int mode)
{
  // Called when ... due to ...
  //   mode == 1: ILControlResume
  //   mode == 2: ILControlStart
  //   mode == 3: ILControlSimulationOn
  //--- begin generated part --- Block start #Hdr_StartSim#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  dword lCAN1BusContext_DateTime;
  dword lCAN1BusContext_ARGT;
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_StartSim#; do not delete this line! Add application code below this line.
  //write("[%.6f %NODE_NAME%] StartSim(0x%X, %d, %d)", TimeNowNS()/1e9, busContext, busActive, mode);
  //--- begin generated part --- Block start #Body_StartSim#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  lCAN1BusContext_DateTime = GetBusNameContext(gCAN1BusName);
  if ((isTimerActive(gCAN1TimerDateTime) == 0) && (busContext == lCAN1BusContext_DateTime) && (busActive == 1)) setTimer(gCAN1TimerDateTime,1); // Simulation of BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3
  lCAN1BusContext_ARGT = GetBusNameContext(gCAN1BusName);
  if ((busContext == lCAN1BusContext_ARGT)) ARGTCAN1_Start(cARGTCAN1_ChannelIdx_0); // Simulation of AUTOSAR Global Time
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_StartSim#; do not delete this line! Add application code below this line.
}

void StopSim(dword busContext, int busActive, int mode)
{
  // Called when ... due to ...
  //   mode == 1: ILControlWait
  //   mode == 2: ILControlStop
  //   mode == 3: ILControlSimulationOff
  //--- begin generated part --- Block start #Hdr_StopSim#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  dword lCAN1BusContext_DateTime;
  dword lCAN1BusContext_ARGT;
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_StopSim#; do not delete this line! Add application code below this line.
  //write("[%.6f %NODE_NAME%] StopSim(0x%X, %d, %d)", TimeNowNS()/1e9, busContext, busActive, mode);
  //--- begin generated part --- Block start #Body_StopSim#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  // For BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3
  lCAN1BusContext_DateTime = GetBusNameContext(gCAN1BusName);
  if (busContext == lCAN1BusContext_DateTime)
  {
    if (isTimerActive(gCAN1TimerDateTime))
      cancelTimer(gCAN1TimerDateTime);
    gCAN1_DateTime_Init = 1;
  }
  lCAN1BusContext_ARGT = GetBusNameContext(gCAN1BusName);
  if ((busContext == lCAN1BusContext_ARGT)) ARGTCAN1_Stop(cARGTCAN1_ChannelIdx_0); // Simulation of AUTOSAR Global Time
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_StopSim#; do not delete this line! Add application code below this line.
}

on sysvar_update sysvar::IL::Klemme15
{
  // Handle system state variable
  //--- begin generated part --- Block start #Hdr_KL15_Klemme15#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_KL15_Klemme15#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_KL15_Klemme15#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  ILCAN1_OnEnvKlemme15(@this);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_KL15_Klemme15#; do not delete this line! Add application code below this line.
}

on sysvar_update sysvar::IL::StartWithoutSending
{
  // Handle system state variable
  //--- begin generated part --- Block start #Hdr_StartManner_StartWithoutSending#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_StartManner_StartWithoutSending#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_StartManner_StartWithoutSending#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  ILCAN1_OnEnvStartWithoutSending(@this);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_StartManner_StartWithoutSending#; do not delete this line! Add application code below this line.
}

on sysvar_update sysvar::IL::UBPlugNPlay
{
  // Handle system state variable
  //--- begin generated part --- Block start #Hdr_UBOpMode_UBPlugNPlay#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_UBOpMode_UBPlugNPlay#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_UBOpMode_UBPlugNPlay#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  SetBusContext(gILCAN1_BusContext);
  ILSetOperationMode(0, @this);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_UBOpMode_UBPlugNPlay#; do not delete this line! Add application code below this line.
}

dword applPDUILTxPending(dword busContext, dword shortId, dword longId, char name[], dword& aPDULength, byte data[])
{
  dword ret = 1;
  //--- begin generated part --- Block start #Hdr_applPDUILTxPending#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_applPDUILTxPending#; do not delete this line! Add application code below this line.
  //write("[%.6f %NODE_NAME%] applPDUILTxPending(0x%X, 0x%X, 0x%X, %s, %d, %d)", TimeNowNS()/1e9, busContext, shortId, longId, name, aPDULength, elcount(data));
  //--- begin generated part --- Block start #Body_applPDUILTxPending#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_applPDUILTxPending#; do not delete this line! Add application code below this line.
  return ret;
}

dword applPDUILStart(dword busContext, dword busActive, dword mode)
{
  dword ret = 1;
  //--- begin generated part --- Block start #Hdr_applPDUILStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_applPDUILStart#; do not delete this line! Add application code below this line.
  //write("[%.6f %NODE_NAME%] applPDUILStart(0x%X, %d, %d)", TimeNowNS()/1e9, busContext, busActive, mode);
  //--- begin generated part --- Block start #Body_applPDUILStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_applPDUILStart#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Footer_applPDUILStart#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  StartSim(busContext, busActive, mode);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Footer_applPDUILStart#; do not delete this line! Add application code below this line.
  return ret;
}

dword applPDUILStop(dword busContext, dword busActive, dword mode)
{
  dword ret = 1;
  //--- begin generated part --- Block start #Hdr_applPDUILStop#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_applPDUILStop#; do not delete this line! Add application code below this line.
  //write("[%.6f %NODE_NAME%] applPDUILStop(0x%X, %d, %d)", TimeNowNS()/1e9, busContext, busActive, mode);
  //--- begin generated part --- Block start #Body_applPDUILStop#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  StopSim(busContext, busActive, mode);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_applPDUILStop#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Footer_applPDUILStop#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Footer_applPDUILStop#; do not delete this line! Add application code below this line.
  return ret;
}

void Nm_NetworkStartInd()
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_NetworkStartInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_NetworkStartInd#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_NetworkStartInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndNetworkStart();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_NetworkStartInd#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

void Nm_NetworkModeInd()
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_NetworkModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_NetworkModeInd#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_NetworkModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndNetworkMode();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_NetworkModeInd#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

void Nm_NetworkTimeoutInd()
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_NetworkTimeoutInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_NetworkTimeoutInd#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_NetworkTimeoutInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndNetworkTimeout();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_NetworkTimeoutInd#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

void Nm_PrepareBusSleepModeInd()
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_PrepareBusSleepModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_PrepareBusSleepModeInd#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_PrepareBusSleepModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndPrepareBusSleepMode();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_PrepareBusSleepModeInd#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

void Nm_BusSleepModeInd()
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_BusSleepModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_BusSleepModeInd#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_BusSleepModeInd#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndBusSleepMode();
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_BusSleepModeInd#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

void Nm_StateChangeNotification(long previousState, long currentState)
{
  // Callback of CAN AUTOSAR NM DLL
  dword lBusContext;
  //--- begin generated part --- Block start #Hdr_Nm_StateChangeNotification#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_Nm_StateChangeNotification#; do not delete this line! Add application code below this line.
  lBusContext = GetBusContext();
  //--- begin generated part --- Block start #Body_Nm_StateChangeNotification#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  if (lBusContext == gNMCAN1_BusContext) NMCAN1_IndStateChangeNotification(previousState, currentState);
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_Nm_StateChangeNotification#; do not delete this line! Add application code below this line.
  SetBusContext(lBusContext);
}

on sysvar_update sysvar::ModelGlobal::ISw_Stat
{
  // Handle system state variable
  //--- begin generated part --- Block start #Hdr_ISw_Stat_ISw_Stat#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_ISw_Stat_ISw_Stat#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_ISw_Stat_ISw_Stat#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  $BODY1::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::ISw_Stat_ST3 = @sysvar::ModelGlobal::ISw_Stat;
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_ISw_Stat_ISw_Stat#; do not delete this line! Add application code below this line.
}

void OnSecurityLocalPDUPreTx(char pduName[], dword dataId, byte payload[], dword payloadLength, qword& authInfoHigh, qword& authInfo, dword authInfoBitLength, qword& freshness, dword freshnessBitLength, dword freshnessValueId)
{
  //--- begin generated part --- Block start #Hdr_OnSecurityLocalPDUPreTx#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnSecurityLocalPDUPreTx#; do not delete this line! Add application code below this line.
  // This is a callback from the node layer DLL 'SecMgrCANoeClient.dll'.
  //write("[%.6f %NETWORK_NAME% %NODE_NAME%] OnSecurityLocalPDUPreTx(PDU \"%s\", DataId: %u, Payload length: %i Byte, AuthInfo: %llu, Freshness: 0x%llX)", TimeNowNS()/1e9, pduName, dataId, payloadLength, authInfo, freshness);
  //--- begin generated part --- Block start #Body_OnSecurityLocalPDUPreTx#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  
  if (strncmp("BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DateTm_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DateTm_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Impact3_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Impact3_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::Mode;
      if (gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::Value;
        }
        gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        freshness = gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        freshness ^= gCAN1SecOCFr_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness;
      }
      if (gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness > 0)
      {
        gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness--;
      }
    }
  }
  
  if (strncmp("BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3", pduName, 256) == 0)
  {
    if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo != 0)
    {
      gCAN1DisturbanceMode = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::Mode;
      if (gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo == 1)
      {
        if (gCAN1DisturbanceMode == 1)
        {
          // Starting disturbance and remember current value for freeze:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = freshness;
        }
        else
        {
          // Retrieve disturbance value from panel:
          gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::Value;
        }
        gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = 0;
      }
      if (gCAN1DisturbanceMode == 0)
      {
        // Disturb by setting dedicated value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 1)
      {
        // Disturb by freezing current value:
        authInfo = gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo;
      }
      else if (gCAN1DisturbanceMode == 2)
      {
        // Disturb by XORing with value:
        authInfo ^= gCAN1SecOCAu_DistVal_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo;
      }
      if (gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo > 0)
      {
        gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo--;
      }
    }
  }
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnSecurityLocalPDUPreTx#; do not delete this line! Add application code below this line.
}

void OnARGTMgr_StatusChanged(word timeDomainIndex, word domainID, enum ARGTMgr_Status status)
{
  //--- begin generated part --- Block start #Hdr_OnARGTMgr_StatusChanged#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnARGTMgr_StatusChanged#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnARGTMgr_StatusChanged#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnARGTMgr_StatusChanged#; do not delete this line! Add application code below this line.
}

void OnARGTMgr_SyncPoint(word timeDomainIndex, word domainID, byte dir, qword timeNs)
{
  //--- begin generated part --- Block start #Hdr_OnARGTMgr_SyncPoint#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnARGTMgr_SyncPoint#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnARGTMgr_SyncPoint#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnARGTMgr_SyncPoint#; do not delete this line! Add application code below this line.
}

void OnARGTMgr_TriggerSyncMessageOnGatewayMasterPorts(word timeDomainIndex, word domainID, qword currentGlobalTimeNs, byte userBytes[], word userBytesLength)
{
  //--- begin generated part --- Block start #Hdr_OnARGTMgr_TriggerSyncMessageOnGatewayMasterPorts#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnARGTMgr_TriggerSyncMessageOnGatewayMasterPorts#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnARGTMgr_TriggerSyncMessageOnGatewayMasterPorts#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  ARGTMgrCAN1_TriggerSyncMessageOnGatewayMasterPorts(timeDomainIndex, domainID, currentGlobalTimeNs, userBytes, userBytesLength); // Simulation of AUTOSAR Global Time
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnARGTMgr_TriggerSyncMessageOnGatewayMasterPorts#; do not delete this line! Add application code below this line.
}

void OnARGTMgr_ValidationError(word timeDomainIndex, word domainID, enum ARGTMgr_Validation validation)
{
  //--- begin generated part --- Block start #Hdr_OnARGTMgr_ValidationError#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Hdr_OnARGTMgr_ValidationError#; do not delete this line! Add application code below this line.
  //--- begin generated part --- Block start #Body_OnARGTMgr_ValidationError#; do not delete this line and do not add application code in this code block!
  /* #ChannelStart# |CAN1| #BusStart# |BODY1| */
  /* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
  //--- end generated part --- Block end #Body_OnARGTMgr_ValidationError#; do not delete this line! Add application code below this line.
}

//--- begin generated part --- Block start <#Helper_Functions#> do not delete this line and do not add application code in this code block!
/* #ChannelStart# |CAN1| #BusStart# |BODY1| */
on timer gCAN1TimerDateTime
{
  // Simulation of BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3
  int max, year;
  long TimeAndDate[9];
  getLocalTime(TimeAndDate);
  if ((gCAN1_DateTime_Init > 0) || ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 > 99 && $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 > 12 && $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 > 31 && $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 > 24 && $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 > 60 && $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 > 60))
  {
    // Zeit- und Datumsangabe setzen; Reihenfolge: langsam ändernd zu schnell ändernd, um möglichst synchron zur Systemzeit zu starten
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 = TimeAndDate[5] % 100; // Year starts at 1900; only last two digits are required
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 = TimeAndDate[4] + 1; // Month
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 = TimeAndDate[3]; // Day
    // Hours: consider also TimeAndDate[8] (means summer time yes/no)
    if (TimeAndDate[8])
    {
      $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 = TimeAndDate[2];
    }
    else
    {
      $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 = TimeAndDate[2] + 1;
    }
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 = TimeAndDate[1]; // Minutes
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 = TimeAndDate[0]; // Seconds
    gCAN1_DateTime_Init = 0;
  }
  else
  {
    if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 >= 59)
    {
      $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 = 0;
      if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 >= 59)
      {
        $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 = 0;
        if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 >= 23)
        {
          $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 = 0;
          if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 1 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 3 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 5 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 7 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 8 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 10 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 12)
          {
            max = 31;
          } 
          else
          {
            if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 4 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 6 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 9 || $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 == 11)
            {
              max = 30;
            }
            else // is February
            {
              year = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 + 2000;
              // check for leap year
              if (((year % 4) == 0) & ((year % 100) != 0) || ((year % 400) == 0))
              {
                // is a leap year
                max = 29;
              }
              else
              {
                // not a leap year
                max = 28;
              }
            }
          }
          if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 >= max)
          {
            $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 = 1;
            if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 >= 12)
            {
              $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 = 1;
              if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 >= 99)
              {
                $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 = 0;
              }
              else
              {
                $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmYear_ST3 + 1;
              }
            }
            else
            {
              $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMonth_ST3 + 1;
            }
          }
          else
          {
            $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmDay_ST3 + 1;
          }
        }
        else
        {
          $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmHour_ST3 + 1;
        }
      }
      else
      {
        $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmMinute_ST3 + 1;
      }
    }
    else
    {
      $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 = $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmSecond_ST3 + 1;
    }
  }
  
  if ($BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmStat_ST3 != 2)
    $BODY1::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::DateTmStat_ST3 = 2;
  
  setTimer(gCAN1TimerDateTime, 1000);
}

/* #ChannelEnd# |CAN1| #BusEnd# |BODY1| */
//--- end generated part --- Block end <#Helper_Functions#> do not delete this line! Add application code below this line.

//--- begin generated part --- Block start <#SysVar_Handler#> do not delete this line and do not add application code in this code block!
/* #ChannelStart# |CAN1| #BusStart# |BODY1| */
on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_HVAC_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_CC_Rq_Mstr_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_Lmp_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_ELC_TurnInd_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_GDO_UI_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FL_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_FR_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RL_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_PW_UI_RR_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_SensorAcquisition_F_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_Pnl_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_R_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_Container_ST3_TSSR_UI_RB_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Bckl_Sw_Fx_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BCS_Brk_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_BSM_Master_Warn_Rq_Pr5_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_RemFunc_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_CLkS_State2_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DateTm_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DateTm_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DateTm_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_OdoSpeedometer_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_DI_Temperature_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_EPKB_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Ign_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Impact3_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Impact3_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Impact3_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_KG_Stat2_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_ORC_Disp_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PLG_DL_Rq_CI_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PN14_Master_Stat1_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_MstrRem_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_Prk_Rem_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor_DrvPosn_Gear_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_PT4_PTCoor4_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_RAS_Park_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_DAS_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ESP_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_ORC_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SADR_Trgr_PARK_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_SVS_ExtLamp_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VehSpd_12_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_Master_Stat_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::UseDisturbanceCount)
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = -1; // disturb continuously
    }
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCFreshness::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCFr_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = 0; // stop disturbance
    gCAN1SecOCFr_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_Freshness = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::Disturb
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  if (@this == 1)
  {
    if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::UseDisturbanceCount)
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::Count; // disturb n-times
    }
    else
    {
      gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = -1; // disturb continuously
    }
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = 1;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3::SecOCAuthInfo::NormalOperation
{
  // Service method call in client/consumer
  // For signal 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo'
  // Of PDU 'BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3'
  if (@this == 1)
  {
    gCAN1SecOCAu_DistCnt_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = 0; // stop disturbance
    gCAN1SecOCAu_DistInit_BODY1_BC_F_BC_F_BODY1_GW_Container_ST3_VTA_PDD_Remote_Rq_ST3_AuthInfo = 0;
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::EnableNode
{
  ILCAN1_Enable(@this && @sysvar::IL_CAN1::enable_AllNodes);
}

on sysvar_update sysvar::IL_CAN1::enable_AllNodes
{
  ILCAN1_Enable(@this && @sysvar::IL_CAN1::NODES::N_BC_F::EnableNode);
}

on sysvar_update sysvar::NM_CAN1::NODES::N_BC_F::DeactivateNM
{
  if( @this == 1 || @sysvar::NM_CAN1::StateControl::DeactivateNM == 1)
  {
    NMCAN1_Enable(0);
  }
  else
  {
    NMCAN1_Enable(1);
  }
}

on sysvar_update sysvar::NM_CAN1::StateControl::DeactivateNM
{
  if( @this == 1 || @sysvar::NM_CAN1::NODES::N_BC_F::DeactivateNM == 1)
  {
    NMCAN1_Enable(0);
  }
  else
  {
    NMCAN1_Enable(1);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEnableTXofPDU
{
  if (@this == 1)
  {
    ILFaultInjectionEnablePDU(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3);
  }
  else
  {
    ILFaultInjectionDisablePDU(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTimingMode
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITimingMode, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITimingMode
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTimingMode == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITimingMode, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueCyclicTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueCyclicPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueCyclicTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseCyclicTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseCyclicPeriod, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseCyclicPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseCyclicTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::SendOnce
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueEventTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseEventTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::DisturbFalseEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AD_UICoord_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEnableTXofPDU
{
  if (@this == 1)
  {
    ILFaultInjectionEnablePDU(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3);
  }
  else
  {
    ILFaultInjectionDisablePDU(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTimingMode
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITimingMode, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITimingMode
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTimingMode == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUAsrTXMode(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITimingMode, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueCyclicTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueCyclicPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueCyclicTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbFalseCyclicTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 0, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseCyclicPeriod, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseCyclicPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbFalseCyclicTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingCyclic(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueCyclicPeriod, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::SendOnce
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueEventTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay
{
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbTrueEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 1, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FITrueEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  if (@sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbFalseEventTiming == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
}

on sysvar_update sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::DisturbFalseEventTiming
{
  if (@this == 1)
  {
    SetBusContext(gILCAN1_BusContext);
    ILSetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 0, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventEnable, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventRepCount, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIFalseEventRepPeriod, @sysvar::IL_CAN1::NODES::N_BC_F::PDUS::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3::TIMINGS::FIEventDebounceDelay, -1, 0);
  }
  else
  {
    SetBusContext(gILCAN1_BusContext);
    ILResetPDUTimingEvent(BODY1::BC_F::BC_F_BODY1_Container_ST3_AICF_Amb_Rq_ST3, 0);
  }
}

